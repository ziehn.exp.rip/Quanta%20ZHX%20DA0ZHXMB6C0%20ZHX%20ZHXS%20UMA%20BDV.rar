# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Nets (continued)
GND: C1.1 C2.1 C3.2 C12.2 C13.2 C14.1 C15.1 C16.1 C17.2 C18.1 C19.1 C22.1 C23.2 C30.2 C33.1 C35.2 C38.2 C41.1 C42.2 C43.2 C44.2 C47.2 C48.2 C49.2 C50.1 C51.1 C52.2 C53.2 C55.2 C56.2 C58.2 C59.1 C60.2 C61.2 C64.2 C67.2 C68.2 C71.1 C73.2 C74.1 C76.1 C78.2 C81.2 C83.2 C86.1 C90.2 C91.2 C92.1 C94.2 C95.2 C97.2 C98.2 C99.2 C100.1 C101.2 C104.2 C108.2 C117.1 C124.2 C125.2 C126.2 C128.1 C129.1 C130.1 C131.1 C132.1 C133.1 C134.2 C135.2 C138.2 C139.2 C140.1 C141.1 C142.2 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.2 C151.1 C152.2 C153.1 C154.1 C155.1 C156.1 C157.2 C158.1 C159.2 C160.1 C161.2 C162.1 C163.1 C164.1 C165.1 C166.1 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C177.1 C178.2 C179.2 C180.1 C182.1 C183.1 C188.1 C191.1 C192.1 C193.1 C194.1 C195.2 C196.1 C199.2 C200.2 C201.1 C202.2 C203.1 C204.2 C205.1 C206.2 C207.1 C208.1 C209.1 C211.1 C213.2 C214.2 C215.1 C216.2 C217.2 C218.2 C219.1 C220.1 C221.1 C222.1 C223.1 C224.1 C225.2 C226.1 C227.1 C228.2 C229.2 C230.2 C231.1 C232.2 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.2 C241.1 C242.1 C243.1 C244.1 C245.1 C247.1 C248.1 C249.1 C250.2 C251.2 C252.2 C253.2 C254.2 C255.1 C256.2 C257.1 C258.1 C259.1 C260.1 C261.1 C262.1 C263.2 C264.2 C265.1 C266.1 C267.1 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.1 C278.2 C279.2 C282.2 C283.2 C284.2 C286.2 C287.2 C288.2 C289.2 C290.2 C292.2 C294.2 C297.2 C314.2 C315.1 C316.1 C317.2 C319.1 C320.2 C321.2 C322.1 C323.2 C324.2 C325.2 C326.1 C327.1 C328.2 C329.1 C330.1 C331.1 C333.2 C334.2 C335.2 C336.2 C337.2 C338.1 C339.1 C340.1 C419.2 C420.1 C423.1 C425.2 C426.2 C427.2 C438.1 C573.1 C575.1 C576.1 C594.2 C595.1 C596.1 C597.2 C601.2 C602.2 C603.2 C604.2 C694.1 C698.2 C700.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C725.2 C726.2 C727.1 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.1 C764.2 C765.2 C766.2 C767.1 C768.1 C769.2 C770.1 C771.1 C772.1 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C795.1 C798.1 C799.1 C800.1 C801.1 C802.1 C803.1 C804.1 C805.1 C806.2 C807.2 C808.1 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C828.2 C839.2 C840.2 C841.2 C842.1 C859.2 C860.2 C861.2 C862.2 C863.2 C864.1 C865.1 C867.1 C868.1 C869.1 C870.1 C871.1 C873.2 C875.2 C876.2 C877.2 C878.2 CN1.4 CN1.7 CN1.10 CN1.11 CN1.12 CN1.13 CN2.2 CN2.5 CN2.8 CN2.11 CN2.17 CN2.20 CN2.21 CN2.22 CN2.23 CN3.5 CN3.8 CN3.12 CN3.13 CN3.14 CN5.1 CN5.7 CN5.18 CN5.33 CN5.39 CN5.45 CN5.51 CN5.57 CN5.63 CN5.69 CN5.75 CN7.2 CN9.1 CN9.4 CN9.7 CN9.11 CN9.12 CN9.13 CN9.17 CN9.19 CN9.23 CN9.24 CN10.13 CN10.17 CN10.20 CN10.23 CN10.26 CN10.29 CN10.32 CN10.38 CN10.41 CN10.42 CN11.28 CN11.29 CN11.30 CN12.4 CN12.9 CN12.10 CN16.5 CN16.8 CN18.1 CN18.3 CN18.5 CN18.27 CN18.33 CN18.39 CN18.45 CN18.51 CN18.57 CN18.69 CN18.71 CN18.73 CN18.75 D2.2 D3.2 D5.2 D11.2 D12.2 D23.2 D24.2 D25.2 D26.2 D29.2 D30.2 D42.2 D43.2 D44.1 G1.2 HOLE2.1 HOLE3.1 HOLE5.1 HOLE6.1 HOLE7.1 HOLE8.1 HOLE10.1 HOLE11.1 HOLE12.1 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 L10.1 MR1.3 MR3.2 PC1.1 PC2.2 PC3.2 PC4.2 PC5.1 PC6.2 PC7.2 PC8.2 PC9.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.1 PC21.2 PC22.2 PC23.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC33.1 PC34.2 PC35.2 PC37.2 PC39.2 PC40.2 PC44.2 PC45.2 PC46.1 PC47.2 PC49.2 PC50.1 PC52.1 PC55.2 PC56.1 PC57.2 PC58.2 PC59.2 PC60.2 PC61.2 PC62.2 PC63.2 PC64.2 PC65.2 PC66.2 PC71.2 PC73.1 PC74.1 PC75.2 PC76.2 PC77.2 PC78.1 PC79.1 PC81.2 PC82.2 PC84.2 PC85.2 PC86.2 PC87.1 PC88.2 PC90.2 PC91.2 PC92.2 PC93.1 PC94.2 PC95.1 PC97.2 PC99.2 PC100.1 PC101.2 PC102.2 PC103.1 PC106.2 PC107.2 PC108.1 PC109.2 PC110.1 PC111.1 PC112.2 PC114.2 PC115.1 PC116.2 PC117.1 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.1 PC124.2 PC125.2 PC126.2 PC127.1 PC128.1 PC130.1 PC131.1 PC133.1 PC135.1 PC136.1 PC137.1 PC138.1 PC139.2 PC140.1 PC141.1 PC142.1 PC143.2 PC144.2 PC145.1 PC146.1 PC147.1 PC148.2 PC149.2 PC150.2 PC151.2 PC152.1 PC153.1 PC154.1 PC155.1 PC156.1 PC157.2 PC158.1 PC159.2 PC160.2 PC161.1 PC163.1 PC164.2 PC165.2 PC166.1 PC167.2 PC168.2 PC169.2 PC170.1 PC171.1 PC172.2 PC173.1 PC174.1 PC175.1 PC176.1 PC177.2 PD4.2 PD9.2 PD10.2 PJ1.2 PJ1.3 PJ1.4 PJ2.1 PJ2.2 PJ2.9 PJ2.10 PQ1.4 PQ3.1 PQ6.5 PQ6.6 PQ6.7 PQ7.5 PQ7.6 PQ7.7 PQ8.1 PQ8.2 PQ8.3 PQ11.1 PQ12.1 PQ14.1 PQ14.2 PQ14.3 PQ16.1 PQ18.1 PQ20.1 PQ22.1 PQ23.1 PQ24.1 PQ27.1 PQ30.1 PQ31.1 PQ33.1 PQ34.1 PQ35.1 PQ36.1 PQ36.4 PQ37.1 PQ38.1 PQ38.4 PQ39.1 PQ39.4 PR5.2 PR13.2 PR23.2 PR34.2 PR43.1 PR49.2 PR66.1 PR70.2 PR82.2 PR102.1 PR112.1 PR115.1 PR116.2 PR119.1 PR124.1 PR141.2 PR142.2 PR149.1 PR189.2 PR200.2 PR211.1 PR219.2 PR224.1 PR239.2 PR240.2 PR241.2 PR242.2 PU1.12 PU1.15 PU1.29 PU2.4 PU2.5 PU2.6 PU3.2 PU4.19 PU4.33 PU5.2 PU6.19 PU6.33 PU7.4 PU7.7 PU7.10 PU7.21 PU8.14 PU8.21 PU8.22 PU8.23 PU8.24 PU8.25 Q2.1 Q3.1 Q5.1 Q7.1 Q10.1 Q12.1 Q13.1 Q13.4 Q14.2 Q16.1 Q19.1 Q21.1 Q23.1 Q24.1 Q35.1 Q35.4 Q38.1 Q38.4 Q40.1 Q41.1 Q42.1 Q75.1 Q76.1 Q78.1 Q79.1 R10.1 R18.1 R22.1 R32.1 R43.1 R44.1 R45.1 R47.1 R50.2 R51.2 R52.2 R53.2 R54.2 R55.2 R60.1 R61.2 R69.1 R73.1 R74.1 R93.1 R100.2 R103.1 R104.1 R110.1 R113.1 R116.1 R123.1 R131.1 R160.1 R163.1 R167.1 R174.1 R183.2 R200.2 R210.2 R218.2 R250.1 R254.2 R289.2 R317.1 R327.2 R333.2 R336.2 R339.2 R340.2 R346.1 R349.2 R350.2 R352.1 R361.1 R363.2 R366.2 R367.1 R368.1 R369.1 R378.1 R384.1 R386.1 R400.2 R403.2 R409.2 R421.2 R422.2 R439.2 R461.2 R514.1 R581.1 R1007.1 R1011.1 R1012.1 R1017.1 R1027.2 R1035.1 R1039.1 R1041.2 R1044.2 R1045.1 R1046.1 R1047.1 R1048.1 R1076.1 R1077.1 R1078.1 R1104.1 R1107.2 R1120.1 R1121.1 R1125.1 R1148.2 R1149.2 R1165.1 R1181.2 R1183.2 R1185.2 R1187.2 R1188.1 R1192.1 R1193.1 R1195.1 R1202.1 R1203.1 SW2.2 SW2.4 SW2.5 SW2.6 U1.2 U4.49 U5.4 U7.A5 U7.A6 U7.A7 U7.A11 U7.A15 U7.A19 U7.A23 U7.A31 U7.A39 U7.A43 U7.A47 U7.AA16 U7.AA27 U7.AA38 U7.AA53 U7.AB4 U7.AB6 U7.AB10 U7.AB12 U7.AB13 U7.AB14 U7.AB42 U7.AB47 U7.AB50 U7.AC16 U7.AC29 U7.AC33 U7.AC35 U7.AC38 U7.AD4 U7.AD21 U7.AD30 U7.AD32 U7.AD36 U7.AD44 U7.AE1 U7.AE6 U7.AE8 U7.AE9 U7.AE11 U7.AE12 U7.AE14 U7.AE40 U7.AE42 U7.AE43 U7.AE45 U7.AE46 U7.AE48 U7.AE50 U7.AE53 U7.AF10 U7.AF24 U7.AF25 U7.AF32 U7.AF38 U7.AF47 U7.AG25 U7.AH9 U7.AH10 U7.AH12 U7.AH13 U7.AH14 U7.AH41 U7.AH42 U7.AH44 U7.AH47 U7.AJ1 U7.AJ3 U7.AJ16 U7.AJ18 U7.AJ25 U7.AJ51 U7.AJ53 U7.AK4 U7.AK7 U7.AK16 U7.AK22 U7.AK25 U7.AK27 U7.AK29 U7.AK32 U7.AK38 U7.AK40 U7.AK44 U7.AK45 U7.AK47 U7.AK50 U7.AM4 U7.AM13 U7.AM16 U7.AM24 U7.AM27 U7.AM30 U7.AM35 U7.AM38 U7.AM42 U7.AM50 U7.AN1 U7.AN3 U7.AN5 U7.AN6 U7.AN8 U7.AN9 U7.AN11 U7.AN12 U7.AN14 U7.AN16 U7.AN21 U7.AN24 U7.AN25 U7.AN29 U7.AN30 U7.AN33 U7.AN38 U7.AN40 U7.AN42 U7.AN43 U7.AN45 U7.AN46 U7.AN48 U7.AN49 U7.AN51 U7.AN53 U7.AP4 U7.AP9 U7.AP45 U7.AP50 U7.AT3 U7.AT9 U7.AT18 U7.AT19 U7.AT27 U7.AT35 U7.AT36 U7.AT45 U7.AT51 U7.AU1 U7.AU3 U7.AU51 U7.AU53 U7.AV14 U7.AV19 U7.AV24 U7.AV27 U7.AV30 U7.AV35 U7.AV40 U7.AW13 U7.AW19 U7.AW27 U7.AW35 U7.AW41 U7.AY3 U7.AY7 U7.AY9 U7.AY20 U7.AY22 U7.AY24 U7.AY26 U7.AY28 U7.AY30 U7.AY32 U7.AY34 U7.AY45 U7.AY47 U7.AY51 U7.B2 U7.B28 U7.B36 U7.B52 U7.BA19 U7.BA24 U7.BA27 U7.BA30 U7.BA35 U7.BB4 U7.BB19 U7.BB27 U7.BB35 U7.BB50 U7.BC10 U7.BC14 U7.BC16 U7.BC26 U7.BC28 U7.BC38 U7.BC40 U7.BC44 U7.BD1 U7.BD19 U7.BD27 U7.BD35 U7.BD53 U7.BE19 U7.BE35 U7.BF4 U7.BF12 U7.BF22 U7.BF26 U7.BF27 U7.BF28 U7.BF32 U7.BF42 U7.BF50 U7.BG1 U7.BG5 U7.BG7 U7.BG14 U7.BG16 U7.BG18 U7.BG19 U7.BG20 U7.BG24 U7.BG27 U7.BG30 U7.BG34 U7.BG35 U7.BG36 U7.BG38 U7.BG40 U7.BG47 U7.BG49 U7.BG53 U7.BH1 U7.BH2 U7.BH52 U7.BH53 U7.BJ7 U7.BJ11 U7.BJ15 U7.BJ19 U7.BJ23 U7.BJ27 U7.BJ31 U7.BJ35 U7.BJ39 U7.BJ43 U7.BJ47 U7.C1 U7.C3 U7.C20 U7.C22 U7.C28 U7.C30 U7.C36 U7.C39 U7.C47 U7.D10 U7.D16 U7.D24 U7.D27 U7.D32 U7.D38 U7.D40 U7.D42 U7.E19 U7.E35 U7.E46 U7.E51 U7.F1 U7.F5 U7.F19 U7.F24 U7.F27 U7.F32 U7.F35 U7.G12 U7.G14 U7.G22 U7.G26 U7.G28 U7.G30 U7.H8 U7.H19 U7.H27 U7.H35 U7.J18 U7.J19 U7.J22 U7.J27 U7.J30 U7.J35 U7.J38 U7.J42 U7.J53 U7.K4 U7.K12 U7.K14 U7.K16 U7.K22 U7.K24 U7.K30 U7.K32 U7.K34 U7.K36 U7.K45 U7.K50 U7.L1 U7.L19 U7.L27 U7.L35 U7.L41 U7.M9 U7.M14 U7.M19 U7.M24 U7.M27 U7.M35 U7.M40 U7.M45 U7.M50 U7.N22 U7.N24 U7.N32 U7.N51 U7.N53 U7.P4 U7.P10 U7.P19 U7.P22 U7.P27 U7.P32 U7.P35 U7.P36 U7.P42 U7.R1 U7.T9 U7.T14 U7.T47 U7.U5 U7.U6 U7.U8 U7.U9 U7.U11 U7.U12 U7.U14 U7.U18 U7.U21 U7.U25 U7.U29 U7.U30 U7.U32 U7.U33 U7.U36 U7.U38 U7.U40 U7.U42 U7.U43 U7.U45 U7.U46 U7.U48 U7.U49 U7.U53 U7.V16 U7.V21 U7.V25 U7.V32 U7.V38 U7.V41 U7.V42 U7.V44 U7.W1 U7.Y4 U7.Y9 U7.Y10 U7.Y14 U7.Y16 U7.Y19 U7.Y21 U7.Y22 U7.Y24 U7.Y29 U7.Y38 U7.Y40 U7.Y45 U7.Y50 U8.5 U9.1 U9.27 U9.49 U9.91 U9.104 U11.2 U12.2 U12.5 U13.4 U13.11 U13.18 U13.25 U14.4 U15.1 U16.2 U17.2 U18.2 U19.1 U20.A6 U20.C4 U20.E7 U20.E9 U20.E10 U20.F10 U20.G5 U20.H10 U20.J5 U20.K8 U20.K10 U20.N2 U20.N5 U20.P4 U20.P6 U21.5 U21.10 U21.12 U21.13 U21.15 U21.16 U23.25 U24.A9 U24.B1 U24.B3 U24.B9 U24.D1 U24.D8 U24.E1 U24.E2 U24.E8 U24.F9 U24.G1 U24.G8 U24.G9 U24.J2 U24.J8 U24.M1 U24.M9 U24.P1 U24.P9 U24.T1 U24.T9 U25.A9 U25.B1 U25.B3 U25.B9 U25.D1 U25.D8 U25.E1 U25.E2 U25.E8 U25.F9 U25.G1 U25.G8 U25.G9 U25.J2 U25.J8 U25.M1 U25.M9 U25.P1 U25.P9 U25.T1 U25.T9 U26.A9 U26.B1 U26.B3 U26.B9 U26.D1 U26.D8 U26.E1 U26.E2 U26.E8 U26.F9 U26.G1 U26.G8 U26.G9 U26.J2 U26.J8 U26.M1 U26.M9 U26.P1 U26.P9 U26.T1 U26.T9 U27.A9 U27.B1 U27.B3 U27.B9 U27.D1 U27.D8 U27.E1 U27.E2 U27.E8 U27.F9 U27.G1 U27.G8 U27.G9 U27.J2 U27.J8 U27.M1 U27.M9 U27.P1 U27.P9 U27.T1 U27.T9 U31.A9 U31.B1 U31.B3 U31.B9 U31.D1 U31.D8 U31.E1 U31.E2 U31.E8 U31.F9 U31.G1 U31.G8 U31.G9 U31.J2 U31.J8 U31.M1 U31.M9 U31.P1 U31.P9 U31.T1 U31.T9 U32.A9 U32.B1 U32.B3 U32.B9 U32.D1 U32.D8 U32.E1 U32.E2 U32.E8 U32.F9 U32.G1 U32.G8 U32.G9 U32.J2 U32.J8 U32.M1 U32.M9 U32.P1 U32.P9 U32.T1 U32.T9 U33.A9 U33.B1 U33.B3 U33.B9 U33.D1 U33.D8 U33.E1 U33.E2 U33.E8 U33.F9 U33.G1 U33.G8 U33.G9 U33.J2 U33.J8 U33.M1 U33.M9 U33.P1 U33.P9 U33.T1 U33.T9 U34.A9 U34.B1 U34.B3 U34.B9 U34.D1 U34.D8 U34.E1 U34.E2 U34.E8 U34.F9 U34.G1 U34.G8 U34.G9 U34.J2 U34.J8 U34.M1 U34.M9 U34.P1 U34.P9 U34.T1 U34.T9 U35.29 U36.2 U37.2 U38.4 VC1.2 Y2.2 Y2.4 Y4.2 Y4.4
GND_VCORE: PC129.2 PR149.2 PR150.2 PU4.5
GND_VGG: PC162.2 PR210.2 PR211.2 PU6.5
PVCC_VCORE: PC141.2 PR170.2 PU4.21
VCC0_SENSEN_R: R141.2 T1.1 U7.AJ32
VCC0_SENSEP_R: R146.2 T4.1 U7.AG32
VCC1_SENSEN: PR150.1 R137.1 R141.1
VCC1_SENSEN_R: R137.2 U7.AF27
VCC1_SENSEP: PR148.1 R144.1 R146.1
VCC1_SENSEP_R: R144.2 U7.AD29
VCC_VCORE: PC50.2 PR55.1 PR166.2 PU4.6
VCCRTC_1: D17.1 R479.1
VCCRTC_2: Q31.3 R411.2
VCCRTC_3: R410.2 R411.1
VCCSRANSOCI_OBS: R386.2 U7.AA30
VDDI_DSC: C315.2 U20.C2
670AGND: PC51.1 PR43.2 PU3.14
671AGND: PC69.1 PR66.2 PR71.2 PU5.14
5041_VCC: PC18.1 PR9.2 PU1.11
24707_LX: PC96.1 PL7.2 PQ8.5 PQ9.1 PQ9.2 PQ9.3 PR86.1 PU8.19
24737_ACDET: PR119.2 PR122.2 PU8.6
24737_ACN: PC104.2 PC109.1 PR140.1 PU8.1
24737_ACP: PC104.1 PC108.2 PR135.1 PU8.2
24737_BM#: PQ11.2 PR91.1 PU8.11
24737_BST: PR109.2 PU8.17
24737_CMPIN: PR124.2 PR130.1 PR131.2 PU8.4
24737_CMPOUT: PQ12.2 PR123.1 PR129.1 PR130.2 PU8.3
24737_DH: PQ9.4 PU8.18
24737_DL: PQ8.4 PU8.15
24737_ILIM: PC93.2 PR92.1 PR102.2 PR105.2 PU8.10
24737_REGN: PC84.1 PD2.2 PU8.16
24737_SRN: PC79.2 PC80.1 PR97.2 PR100.1
24737_SRP: PC78.2 PC80.2 PR96.2 PR101.1
24737_VCC: PC103.2 PR126.2 PU8.20
51216DRVH: PQ13.4 PU7.14
51216DRVL: PQ14.4 PU7.11
51216MODE: PR112.2 PU7.19
51216PG: PR110.1 PU7.20
51216REFIN: PC97.1 PR111.2 PR116.1 PU7.8
51216S3: PC101.1 PR118.1 PR237.1 PU7.17
51216S5: PC102.1 PR121.1 PU7.16
51216SW: PC105.2 PL8.1 PQ13.1 PQ13.2 PQ13.3 PQ14.5 PR231.2 PU7.13
51216TRIP: PR115.2 PU7.18
+CLKDDR_1P35_PWR: C264.1 C269.1 C271.1 R437.1 U7.AM25
+G_SEN_PW: C314.1 C321.1 R486.2 U21.1 U21.8 U21.14
+LCDVCC: CN10.5 CN10.6 CN10.7 R385.2
+PLLDDR_1P35_PWR: C263.1 C268.1 C273.1 R436.1 U7.AN27
+TPVDD_1: C324.1 C325.1 C333.1 CN12.1 Q44.2 Q45.3 R493.2 R495.2 R496.1 R502.2 R506.2 R510.2 R512.1 R513.1
+V_SMDDR_VREF_DIMM: C47.1 C719.2 C732.1 C733.1 C734.1 C735.1 C764.1 C765.1 C766.1 R1040.2 R1041.1 U24.M8 U25.M8 U26.M8 U27.M8 U31.M8 U32.M8 U33.M8 U34.M8
+V_SMDDR_VREF_DQ0: C727.2 C745.1 C746.1 C747.1 C748.1 R1042.2 R1044.1 U24.H1 U25.H1 U31.H1 U32.H1
+V_SMDDR_VREF_DQ1: C773.1 C774.1 C775.1 C776.1 C795.2 R1107.1 R1108.2 U26.H1 U27.H1 U33.H1 U34.H1
+VGG: C227.2 C229.1 C230.1 C252.1 C253.1 C254.1 C604.1 PC59.1 PC143.1 PC144.1 PC177.1 PL5.2 PR216.2 U7.AD16 U7.AD18 U7.AD19 U7.AF16 U7.AF18 U7.AF19 U7.AF21 U7.AF22 U7.AG16 U7.AG18 U7.AG19 U7.AG21 U7.AG22 U7.AG24 U7.AJ19 U7.AJ21 U7.AJ22 U7.AJ24 U7.AK24
+VREF_VCORE: PC40.1 PR26.2 PR54.2 PR161.2 PU4.1
+VREF_VGG: PC159.1 PR28.2 PR81.2 PR207.2 PU6.1
+VRTC_3P3: C150.1 C159.1 R318.2 U7.B6 U7.C5
AC_PRESENT: Q23.3 R33.2 R1011.2 U7.C13
AC_PROTECT: PR129.2 U9.4
ACCEL_INTA: C326.2 Q43.1 R489.2 R504.1 U21.11
ACIN: PQ36.3 PR228.1 U9.72
ACPRESENT: PR220.1 PR222.1 Q21.2
ACZ_BCLK: R202.1 U7.AD9
ACZ_RST#: R206.1 U7.AF13
ACZ_RST#_AUDIO: Q11.1 R124.1
ACZ_RST#_AUDIO_R: D10.1 Q11.3 R252.1
ACZ_SDIN: R63.1 U4.8
ACZ_SDOUT: R208.1 U7.AF14
ACZ_SPKR: D8.2 U7.H4
ACZ_SYNC: R203.1 U7.AF12
ADOGND: C22.2 C23.1 C24.2 C26.2 C27.2 C31.2 C32.2 C36.2 C45.1 C60.1 C62.1 C65.2 C69.2 C879.2 C880.2 D27.2 D28.2 Q6.1 Q6.4 R67.1 R321.2 R327.1 R336.1 R339.1 R350.1 U4.25 U4.38
ALERT#: TP10.1 U8.6
ALERT#_VCORE: PR36.2 PR171.2 PU4.14
ALERT#_VGG: PR73.2 PR197.2 PU6.14
AMP_MUTE#: D9.1 U9.108
BAT-V: PC91.1 PC92.1 PC110.2 PC165.1 PC166.2 PJ2.7 PJ2.8 PQ10.5 PR97.1 PR113.2
BATLED0#: R266.2 U9.29
BATLED1#: R267.2 U9.25
BATT_EN#: PJ2.6 PR224.2 R1171.1 SW3.3 SW3.4
BATT_EN#_R: Q12.3 R1171.2 SW3.1 SW3.2
BEEP_1: C30.1 C34.2 R25.1 R32.2
BI_GATE: C125.1 Q12.2 Q13.5 R998.2 SW2.1 SW2.3
BIOS_STRAP: R200.1 R201.2 U7.AK10
BL#: Q3.2 Q5.3 R306.2 R310.2
BLON_CON: CN10.15 D15.2 Q3.3 Q24.3 R293.2 R301.1
BMPD_1P05_PWR: C151.2 C154.2 C163.2 R319.2 U7.U22 U7.U24 U7.U27 U7.V22 U7.V24 U7.V27
BOARD_ID0: R1026.2 R1027.1 U7.A9
BOARD_ID1: R34.2 R55.1 R308.2 U7.C9
BOARD_ID2: R40.2 R54.1 U7.B8
BOARD_ID3: R37.2 R53.1 U7.B7
BOARD_ID4: R36.2 R52.1 U7.B5
BOARD_ID5: R35.2 R51.1 U7.B4
BOOT_VCORE: PR31.2 PU4.22
BOOT_VGG: PR56.2 PU6.22
BRIGHT: CN10.14 R382.1
BRTC_EXTPAD: C142.1 U7.F16
BT_EN_R: CN5.54 R821.1
BT_POWERON: C694.2 R821.2 U9.82
C_TX0_HDMI+: C10.2 CN2.7 R5.1 R271.2
C_TX0_HDMI-: C11.2 CN2.9 R5.2 R270.2
C_TX1_HDMI+: C4.2 CN2.4 R2.1 R277.2
C_TX1_HDMI-: C5.2 CN2.6 R2.2 R276.2
C_TX2_HDMI+: C8.2 CN2.1 R4.1 R273.2
C_TX2_HDMI-: C9.2 CN2.3 R4.2 R272.2
C_TXC_HDMI+: C6.2 CN2.10 R3.1 R275.2
C_TXC_HDMI-: C7.2 CN2.12 R3.2 R274.2
CARD_3V3: C419.1 C420.2 CN16.6 U23.5
CCD_PWR: C74.2 C78.1 CN10.9 R1206.2
CF1_3P3_PWR: C167.1 R328.2 R329.2 R1031.2 U7.G1
CF3_3P3_PWR: C161.1 C169.1 R1126.2 R1127.2 U7.E1 U7.E2
CLK_24M_DEBUG: R120.1 R332.1
CLK_24M_DEBUG_C: CN5.71 R332.2
CLK_24M_KBC: R112.1 R249.2 U9.13
CLK_PCIE_WLANN: CN5.49 U7.B18
CLK_PCIE_WLANP: CN5.47 U7.C18
CLK_TPM: C240.1 R121.1 U13.21
CLKRUN#: R126.1 R233.2 R415.1
CLKRUN#R: R233.1 U9.93
COMP_VCORE: PC43.1 PR163.2 PU4.2
COMP_VGG: PC83.1 PR212.2 PU6.2
CORE_1P05_PWR: C191.2 C192.2 C196.2 C203.2 C208.2 C209.2 C219.2 R365.2 R377.2 U7.AA32 U7.AA33 U7.AA35 U7.AA36 U7.AC32 U7.V33 U7.Y30 U7.Y32 U7.Y33 U7.Y35
CORE_1P8_PWR: C228.1 R398.2 R402.2 U7.AF4 U7.AH4
CORE_PWROK: C173.1 R161.2 R167.2 R178.2 U7.G16
CORE_V1P15_PWR: C234.2 C243.2 C244.2 C245.2 C249.2 C255.2 C603.1 R414.1 R417.1 U7.AK30 U7.AK35 U7.AK36 U7.AM29
CR_EN: Q78.2 U7.L13
D/C#: PR10.1 U9.68
DDI1_EDP_HPD_R: Q10.3 R227.2 U7.R51
DDI_1P15_PWR: C247.2 C259.2 C260.2 R444.1 U7.AJ35 U7.AK21 U7.AK33 U7.AM19
DDI_1P24_PWR: C195.1 R354.1 U7.V36 U7.Y36
DDR_1P05_PWR: C248.2 C261.2 C262.2 R425.1 R426.1 U7.AM21 U7.AM22 U7.AM32 U7.AM33 U7.AN22 U7.AN32
DEVSLP0: Q53.1 R173.2 R1025.2 U7.AG1
DEVSLP0_R: Q53.3 R1021.2 R1022.2 R1025.1
DGPU_CL_HDMIP: Q19.3 R270.1 R271.1 R272.1 R273.1 R274.1 R275.1 R276.1 R277.1
DGPU_EVENT#_Q: TP34.1 U7.AD14
DGPU_HOLD_RST#_Q: TP26.1 U7.Y6
DGPU_PWR_EN_Q: TP29.1 U7.V10
DGPU_PWROK_Q: TP24.1 U7.V9
DMIC_CLK: C55.1 CN10.39 R83.1
DMIC_CLK_R: R83.2 U4.3
DMIC_DAT: C873.1 CN10.40 U4.2
DNBSWON#: U9.123 U17.1
DPWROK_EC: R178.1 U9.83
DPY_1P24_PWR: C178.1 C179.1 R334.1 U7.P40 U7.T40
DRAM_RCOMP0: R422.1 U7.BA28
DRAM_RCOMP1: R421.1 U7.BA26
DRM_PWOK_C1: Q38.2 Q38.3 R470.2
DRM_PWOK_C2: Q35.2 Q35.3 R463.2
EC_107: R1158.1 R1159.1 U9.107
EC_114: R1161.2 R1162.2 U9.114
EC_119: R1163.2 U9.119
EC_122: R1164.2 R1165.2 U9.122
EC_125: R1166.2 R1167.2 U9.125
EC_FB_CLAMP: R244.1 R248.1 U9.77
EC_FPBACK#: Q24.2 U9.86
EC_OVERRIDE: R295.2 U9.109
EC_PWROK: Q35.5 R161.1 U9.33
EC_RTC_RST: Q75.2 Q76.2 R1035.2 R1039.2 U9.79
EC_SYS_SHDN#: R1204.1 U9.76
ECAGND: C118.2 C121.1 L10.2 U9.75
EDP_AUX#_C: C70.1 CN10.19 R108.2
EDP_AUX_C: C63.1 CN10.18 R104.2
EDP_HPD: CN10.16 R819.2
EDP_TX0#_C: C80.2 CN10.25
EDP_TX0_C: C79.2 CN10.24
EDP_TX1#_C: C812.2 CN10.22
EDP_TX1_C: C813.2 CN10.21
EEPROM_SCL: TP49.1 U35.18
EEPROM_SDA: TP47.1 U35.26
EMMC_CLK: R362.2 U20.M6
EMMC_CLK_R: R362.1 U7.M7
EMMC_CMD: R500.2 U7.P6 U20.M5
EMMC_DATA_0: U7.M6 U20.A3
EMMC_DATA_1: U7.M4 U20.A4
EMMC_DATA_2: U7.P9 U20.A5
EMMC_DATA_3: U7.P7 U20.B2
EMMC_DATA_4: U7.T6 U20.B3
EMMC_DATA_5: U7.T7 U20.B4
EMMC_DATA_6: U7.T10 U20.B5
EMMC_DATA_7: U7.T12 U20.B6
EMMC_RCLK: R494.2 R1017.2 U20.H5
EXT_LED_1#: PQ38.5 PR239.1 U9.96
EXT_LED_1#_R: CN10.33 PQ38.3
EXT_LED_2#: PQ38.2 PR240.1 U9.97
EXT_LED_2#_R: CN10.34 PQ38.6
EXT_LED_3#: PQ39.5 PR241.1 U9.98
EXT_LED_3#_R: CN10.36 PQ39.3
EXT_LED_4#: PQ39.2 PR242.1 U9.99
EXT_LED_4#_R: CN10.37 PQ39.6
FAN1_PWM: R256.2 U9.32
FAN2_PWM: R255.1 U9.31
FB_CLAMP_REQ#_Q: TP31.1 U7.AD13
FB_VCORE: PR30.2 PR32.1 PR33.1 PR165.2 PU4.3
FB_VGG: PR98.2 PR106.1 PR214.1 PR215.2 PU6.3
FST_SPI_D0: R68.2 U7.V2
FST_SPI_D1: R85.2 U7.V3
FST_SPI_D2: R70.1 U7.U1
FST_SPI_D2_R: R70.2 R77.2 U5.3
FST_SPI_D3: R84.1 U7.U3
FST_SPI_D3_R: R84.2 R92.2 U5.7
FUSE1_1P05_PWR: C177.2 R324.1 U7.G10 U7.H10
FUSE3_1P05_PWR: C160.2 R326.1 U7.N18
FUSE_1P05_PWR: C155.2 C164.2 R325.1 U7.U19
FUSE_1P8_PWR: C193.2 R353.1 U7.U16
GP_CAMERASB08: R122.1 R123.2 U7.Y44
GP_CAMERASB09: R116.2 R117.1 U7.Y42
GP_CAMERASB11: R110.2 R111.1 U7.V40
GPIO0: TP52.1 U23.17
GPIO8: C700.1 R42.1 R308.1
GPIO8_R: CN10.12 R42.2
GPIO_SUS0: R18.2 R23.1 U7.AD51
GPIO_SUS1: R22.2 R30.1 U7.AD52
GPIO_SUS2: R359.1 R367.2 U7.AH50
GPIO_SUS3: R1007.2 R1008.1 U7.AH48
GPIO_SUS4: R127.1 R131.2 U7.AH51
GPIO_SUS5: Q16.3 R97.1 R103.2 U7.AH52
GPIO_SUS6: R1009.1 U7.AG51
GPIO_SUS7: R1010.1 R1019.1 U7.AG53
GPIO_SUS8: R47.2 R64.1 U7.AF52
GPIO_SUS9: R76.2 R93.2 U7.AF51
GPIO_SUS10: R43.2 R48.1 U7.AE51
GPIO_SUS11: R581.2 U7.AC51
GPIOCF1_1P8_PWR: C250.1 C251.1 R424.1 U7.AD33 U7.AF33 U7.AK18 U7.AK19
GPIOCF2_1P8_PWR: C199.1 C200.1 C204.1 D44.2 R364.1 U7.Y18
GSENSOR_INT: Q43.3 R56.1 R489.1 U7.C7
H_PROCHOT#: PQ12.3 PR128.1 PR172.2 PR204.2 PU4.12 PU6.12 Q40.3 R136.1
HDD_INTA: R578.2 U21.9
HDD_INTA_R: CN9.18 R578.1
HDMI_5V: C134.1 CN2.18 D11.1 Q14.1
HDMI_HPD: C135.1 CN2.19 Q2.2 R10.2 VC1.1
HDMI_HPD_CON: Q2.3 R19.1 U7.W51
HDMI_SCLK: CN2.15 Q1.3 R269.2
HDMI_SDATA: CN2.16 Q1.6 R268.2
HP_AGND: CN6.5 CN6.7 R321.1
HP_JD#: CN6.6 R29.2
HPL: C28.2 R21.2 R26.1 U4.32
HPL-1: L3.2 R21.1
HPL_SYS: C27.1 CN6.1 L3.1
HPR: C25.2 R20.2 R28.1 U4.33
HPR-1: L2.2 R20.1
HPR_SYS: C24.1 CN6.2 L2.1
HUB_RREF: R1121.2 U35.8
HWPG: D18.2 D19.2 D20.2 D21.2 R481.1 U9.21
HWPG_1.05V_EC#: PR134.1 R1159.2 R1164.1
HWPG_1.35V: D19.1 PR104.1 PR110.2 Q38.6 R452.1 R465.1
I2C_0_SCL: R198.1 U7.AK6 U19.3
I2C_0_SCL_C: CN12.6 R502.1 U19.6
I2C_0_SDA: R194.1 U7.AH7 U19.4
I2C_0_SDA_C: CN12.5 R506.1 U19.5
I2C_1_SCL: R193.1 U7.AF6
I2C_1_SDA: R189.1 U7.AH6
I2C_2_SCL: R180.1 U7.AF9
I2C_2_SDA: R186.1 U7.AF7
I2C_3_SCL: R171.1 U7.AE4
I2C_3_SDA: R158.1 U7.AD2
I2C_4_SCL: R156.1 U7.AC1
I2C_4_SDA: R157.1 U7.AD3
I2C_5_SCL: R154.1 U7.AB2
I2C_5_SDA: R155.1 U7.AC3
I2C_6_SCL: R1128.1 U7.AA1
I2C_6_SDA: R1129.1 U7.AB3
I2C_NFC_SOC_SCL: R151.1 U7.AA3
I2C_NFC_SOC_SDA: R150.1 U7.Y2
ICLK_1P05_PWR: C211.2 C215.2 R381.1 U7.V18 U7.V19
ICLK_ICOMP: R369.2 U7.P20
ICLK_RCOMP: R361.2 U7.N20
ICLK_VSFR_1P24_PWR: C157.1 C165.2 R316.1 U7.Y25 U7.Y27
ICMNT: C121.2 PC100.2 PR131.1 PU8.7 U9.67
IN_CLK: C6.1 U7.G53
IN_CLK#: C7.1 U7.G52
IN_D0: C10.1 U7.F53
IN_D0#: C11.1 U7.F52
IN_D1: C4.1 U7.H49
IN_D1#: C5.1 U7.H50
IN_D2: C8.1 U7.D50
IN_D2#: C9.1 U7.C51
INT_EDP_AUXN: C70.2 U7.K42
INT_EDP_AUXP: C63.2 U7.M42
INT_EDP_TXN0: C80.1 U7.H51
INT_EDP_TXN1: C812.1 U7.K52
INT_EDP_TXP0: C79.1 U7.J51
INT_EDP_TXP1: C813.1 U7.K51
IOAC_RST#: R297.2 U9.85
IOAC_WLANPWR#: R128.2 U9.35
ISEN1N_VCORE: PR25.1 PU4.27
ISEN1N_VGG: PR74.1 PU6.27
ISEN1P_VCORE: PC24.2 PR20.1 PR21.1 PU4.28
ISEN1P_VGG: PC70.2 PR63.2 PR72.1 PU6.28
L_SPK+: R260.1 U4.42
L_SPK+_1: C128.2 CN13.4 R260.2
L_SPK-: R261.1 U4.43
L_SPK-_1: C129.2 CN13.3 R261.2
LAD0: R238.2 U7.M3 U9.10 U13.26
LAD0_C: CN5.64 R238.1
LAD1: R239.2 U7.M2 U9.9 U13.23
LAD1_C: CN5.66 R239.1
LAD2: R241.2 U7.N3 U9.8 U13.20
LAD2_C: CN5.68 R241.1
LAD3: R245.2 U7.N1 U9.7 U13.17
LAD3_C: CN5.70 R245.1
LED_PWR: CN10.8 R114.2 R1207.2
LFRAME#: R236.1 U7.P3 U9.6 U13.22
LFRAME#_C: CN5.73 R236.2
LGATE_VCORE: PQ7.8 PU4.20
LGATE_VGG: PQ6.8 PU6.20
LID#: C597.1 D43.1 R1001.2 U9.118
LID#_1: C573.2 D12.1 D15.1 D29.1 MR1.2 MR3.4 R281.2 R990.1 R1001.1
LID_OPEN_OUT2_R_L: C575.2 D30.1 MR3.1 R991.1
LINE1-L: C28.1 U4.22
LINE1-R: C25.1 U4.21
LINE1-VREFO-L: R26.2 U4.31
LINE1-VREFO-R: R28.2 U4.30
LPC_RCOMP: R363.1 U7.T4
LX_1P8: PL2.1 PU1.27 PU1.28
M_A_A0: R1049.2 U7.BB47 U24.N3 U25.N3 U31.N3 U32.N3
M_A_A1: R1051.2 U7.BC42 U24.P7 U25.P7 U31.P7 U32.P7
M_A_A2: R1053.2 U7.BJ48 U24.P3 U25.P3 U31.P3 U32.P3
M_A_A3: R1058.2 U7.BH47 U24.N2 U25.N2 U31.N2 U32.N2
M_A_A4: R1050.2 U7.BD42 U24.P8 U25.P8 U31.P8 U32.P8
M_A_A5: R1056.2 U7.BH48 U24.P2 U25.P2 U31.P2 U32.P2
M_A_A6: R1052.2 U7.BB46 U24.R8 U25.R8 U31.R8 U32.R8
M_A_A7: R1057.2 U7.BE46 U24.R2 U25.R2 U31.R2 U32.R2
M_A_A8: R1065.2 U7.BD44 U24.T8 U25.T8 U31.T8 U32.T8
M_A_A9: R1072.2 U7.BE52 U24.R3 U25.R3 U31.R3 U32.R3
M_A_A10: R1071.2 U7.BJ45 U24.L7 U25.L7 U31.L7 U32.L7
M_A_A11: R1066.2 U7.BB49 U24.R7 U25.R7 U31.R7 U32.R7
M_A_A12: R1068.2 U7.BF48 U24.N7 U25.N7 U31.N7 U32.N7
M_A_A13: R1069.2 U7.BF44 U24.T3 U25.T3 U31.T3 U32.T3
M_A_A14: R1067.2 U7.BD47 U24.T7 U25.T7 U31.T7 U32.T7
M_A_A15: R1070.2 U7.BD49 U24.M7 U25.M7 U31.M7 U32.M7
M_A_BS0: R1062.2 U7.BH46 U24.M2 U25.M2 U31.M2 U32.M2
M_A_BS1: R1061.2 U7.AY40 U24.N8 U25.N8 U31.N8 U32.N8
M_A_BS2: R1063.2 U7.BF52 U24.M3 U25.M3 U31.M3 U32.M3
M_A_CAS#: R1059.2 U7.BG45 U24.K3 U25.K3 U31.K3 U32.K3
M_A_CKE0: R1055.2 U7.BB44 U24.K9 U25.K9 U31.K9 U32.K9
M_A_CLKN0: C750.1 R1075.2 U7.BF40 U24.K7 U25.K7 U31.K7 U32.K7
M_A_CLKP0: C750.2 R1074.2 U7.BD40 U24.J7 U25.J7 U31.J7 U32.J7
M_A_CLKP0_N0_C: C749.2 R1074.1 R1075.1
M_A_CS#0: R1054.2 U7.AY38 U24.L2 U25.L2 U31.L2 U32.L2
M_A_DM0: U7.AP52 U31.E7
M_A_DM1: U7.AT48 U24.E7
M_A_DM2: U7.AP44 U31.D3
M_A_DM3: U7.BA53 U24.D3
M_A_DM4: U7.BG41 U32.D3
M_A_DM5: U7.AY36 U25.E7
M_A_DM6: U7.BD32 U32.E7
M_A_DM7: U7.BH30 U25.D3
M_A_DQ0: U7.AK51 U31.H7
M_A_DQ1: U7.AL51 U31.F7
M_A_DQ2: U7.AT52 U31.F2
M_A_DQ3: U7.AR51 U31.E3
M_A_DQ4: U7.AL53 U31.F8
M_A_DQ5: U7.AK52 U31.H8
M_A_DQ6: U7.AR53 U31.H3
M_A_DQ7: U7.AP51 U31.G2
M_A_DQ8: U7.AP48 U24.H3
M_A_DQ9: U7.AT47 U24.E3
M_A_DQ10: U7.AY48 U24.F8
M_A_DQ11: U7.AV50 U24.H7
M_A_DQ12: U7.AP47 U24.G2
M_A_DQ13: U7.AT50 U24.F2
M_A_DQ14: U7.AY50 U24.F7
M_A_DQ15: U7.AV45 U24.H8
M_A_DQ16: U7.AT40 U31.C8
M_A_DQ17: U7.AP42 U31.A7
M_A_DQ18: U7.AT38 U31.C2
M_A_DQ19: U7.AP40 U31.D7
M_A_DQ20: U7.AT44 U31.A3
M_A_DQ21: U7.AV41 U31.C3
M_A_DQ22: U7.AP41 U31.B8
M_A_DQ23: U7.AV42 U31.A2
M_A_DQ24: U7.BD52 U24.D7
M_A_DQ25: U7.AV52 U24.A2
M_A_DQ26: U7.BC53 U24.C8
M_A_DQ27: U7.AV51 U24.A3
M_A_DQ28: U7.AW51 U24.C2
M_A_DQ29: U7.BC52 U24.B8
M_A_DQ30: U7.AW53 U24.C3
M_A_DQ31: U7.BB51 U24.A7
M_A_DQ32: U7.BG42 U32.B8
M_A_DQ33: U7.BG43 U32.D7
M_A_DQ34: U7.BG37 U32.C2
M_A_DQ35: U7.BJ37 U32.A3
M_A_DQ36: U7.BH42 U32.C8
M_A_DQ37: U7.BJ41 U32.A7
M_A_DQ38: U7.BH36 U32.A2
M_A_DQ39: U7.BH38 U32.C3
M_A_DQ40: U7.BC36 U25.F2
M_A_DQ41: U7.BA36 U25.H3
M_A_DQ42: U7.AU34 U25.F7
M_A_DQ43: U7.AU32 U25.H7
M_A_DQ44: U7.BF36 U25.G2
M_A_DQ45: U7.BD36 U25.E3
M_A_DQ46: U7.AV34 U25.F8
M_A_DQ47: U7.AV32 U25.H8
M_A_DQ48: U7.BF34 U32.H7
M_A_DQ49: U7.BC34 U32.H8
M_A_DQ50: U7.BA32 U32.E3
M_A_DQ51: U7.BD30 U32.F2
M_A_DQ52: U7.BD34 U32.F7
M_A_DQ53: U7.BA34 U32.F8
M_A_DQ54: U7.BF30 U32.H3
M_A_DQ55: U7.BD28 U32.G2
M_A_DQ56: U7.BJ33 U25.A3
M_A_DQ57: U7.BG29 U25.A7
M_A_DQ58: U7.BH34 U25.A2
M_A_DQ59: U7.BG32 U25.C3
M_A_DQ60: U7.BG28 U25.C8
M_A_DQ61: U7.BJ29 U25.D7
M_A_DQ62: U7.BH28 U25.B8
M_A_DQ63: U7.BG33 U25.C2
M_A_DQSN0: U7.AM51 U31.G3
M_A_DQSN1: U7.AV48 U24.G3
M_A_DQSN2: U7.AT41 U31.B7
M_A_DQSN3: U7.BA51 U24.B7
M_A_DQSN4: U7.BG39 U32.B7
M_A_DQSN5: U7.AT34 U25.G3
M_A_DQSN6: U7.BC32 U32.G3
M_A_DQSN7: U7.BG31 U25.B7
M_A_DQSP0: U7.AM52 U31.F3
M_A_DQSP1: U7.AV47 U24.F3
M_A_DQSP2: U7.AT42 U31.C7
M_A_DQSP3: U7.AY52 U24.C7
M_A_DQSP4: U7.BH40 U32.C7
M_A_DQSP5: U7.AT32 U25.F3
M_A_DQSP6: U7.BC30 U32.F3
M_A_DQSP7: U7.BH32 U25.C7
M_A_DRAMRST#: U7.BA42 U24.T2 U25.T2 U31.T2 U32.T2
M_A_ODT0: R1073.2 U7.AV36 U24.K1 U25.K1 U31.K1 U32.K1
M_A_RAS#: R1064.2 U7.BA40 U24.J3 U25.J3 U31.J3 U32.J3
M_A_VREF_CA: U7.AT28
M_A_VREF_DQ: U7.AU28
M_A_WE#: R1060.2 U7.BH44 U24.L3 U25.L3 U31.L3 U32.L3
M_A_ZQ1: R1045.2 U31.L8
M_A_ZQ2: R1046.2 U24.L8
M_A_ZQ3: R1047.2 U32.L8
M_A_ZQ4: R1048.2 U25.L8
M_B_A0: R1091.2 U7.BB7 U26.N3 U27.N3 U33.N3 U34.N3
M_B_A1: R1098.2 U7.BC12 U26.P7 U27.P7 U33.P7 U34.P7
M_B_A2: R1083.2 U7.BJ6 U26.P3 U27.P3 U33.P3 U34.P3
M_B_A3: R1081.2 U7.BH7 U26.N2 U27.N2 U33.N2 U34.N2
M_B_A4: R1080.2 U7.BD12 U26.P8 U27.P8 U33.P8 U34.P8
M_B_A5: R1099.2 U7.BH6 U26.P2 U27.P2 U33.P2 U34.P2
M_B_A6: R1084.2 U7.BB8 U26.R8 U27.R8 U33.R8 U34.R8
M_B_A7: R1096.2 U7.BE8 U26.R2 U27.R2 U33.R2 U34.R2
M_B_A8: R1101.2 U7.BD10 U26.T8 U27.T8 U33.T8 U34.T8
M_B_A9: R1079.2 U7.BE2 U26.R3 U27.R3 U33.R3 U34.R3
M_B_A10: R1085.2 U7.BJ9 U26.L7 U27.L7 U33.L7 U34.L7
M_B_A11: R1089.2 U7.BB5 U26.R7 U27.R7 U33.R7 U34.R7
M_B_A12: R1087.2 U7.BF6 U26.N7 U27.N7 U33.N7 U34.N7
M_B_A13: R1093.2 U7.BF10 U26.T3 U27.T3 U33.T3 U34.T3
M_B_A14: R1092.2 U7.BD7 U26.T7 U27.T7 U33.T7 U34.T7
M_B_A15: R1088.2 U7.BD5 U26.M7 U27.M7 U33.M7 U34.M7
M_B_BS0: R1090.2 U7.BH8 U26.M2 U27.M2 U33.M2 U34.M2
M_B_BS1: R1100.2 U7.AY14 U26.N8 U27.N8 U33.N8 U34.N8
M_B_BS2: R1097.2 U7.BF2 U26.M3 U27.M3 U33.M3 U34.M3
M_B_CAS#: R1094.2 U7.BG9 U26.K3 U27.K3 U33.K3 U34.K3
M_B_CKE0: R1103.2 U7.BB10 U26.K9 U27.K9 U33.K9 U34.K9
M_B_CLKN0: C794.1 R1106.2 U7.BF14 U26.K7 U27.K7 U33.K7 U34.K7
M_B_CLKP0: C794.2 R1105.2 U7.BD14 U26.J7 U27.J7 U33.J7 U34.J7
M_B_CLKP0_N0_C: C793.2 R1105.1 R1106.1
M_B_CS#0: R1082.2 U7.AY16 U26.L2 U27.L2 U33.L2 U34.L2
M_B_DM0: U7.AP2 U33.D3
M_B_DM1: U7.AT6 U33.E7
M_B_DM2: U7.AP10 U27.E7
M_B_DM3: U7.BA1 U27.D3
M_B_DM4: U7.BG13 U34.D3
M_B_DM5: U7.AY18 U26.E7
M_B_DM6: U7.BD22 U34.E7
M_B_DM7: U7.BH24 U26.D3
M_B_DQ0: U7.AK3 U33.C2
M_B_DQ1: U7.AL3 U33.A3
M_B_DQ2: U7.AT2 U33.C8
M_B_DQ3: U7.AR3 U33.A7
M_B_DQ4: U7.AL1 U33.C3
M_B_DQ5: U7.AK2 U33.A2
M_B_DQ6: U7.AR1 U33.D7
M_B_DQ7: U7.AP3 U33.B8
M_B_DQ8: U7.AP6 U33.F7
M_B_DQ9: U7.AT7 U33.H3
M_B_DQ10: U7.AY6 U33.F2
M_B_DQ11: U7.AV4 U33.G2
M_B_DQ12: U7.AP7 U33.H8
M_B_DQ13: U7.AT4 U33.H7
M_B_DQ14: U7.AY4 U33.F8
M_B_DQ15: U7.AV9 U33.E3
M_B_DQ16: U7.AT14 U27.F7
M_B_DQ17: U7.AP12 U27.H7
M_B_DQ18: U7.AT16 U27.G2
M_B_DQ19: U7.AP14 U27.F8
M_B_DQ20: U7.AT10 U27.E3
M_B_DQ21: U7.AV13 U27.F2
M_B_DQ22: U7.AP13 U27.H8
M_B_DQ23: U7.AV12 U27.H3
M_B_DQ24: U7.BD2 U27.C3
M_B_DQ25: U7.AV2 U27.C8
M_B_DQ26: U7.BC1 U27.A3
M_B_DQ27: U7.AV3 U27.B8
M_B_DQ28: U7.AW3 U27.A7
M_B_DQ29: U7.BC2 U27.A2
M_B_DQ30: U7.AW1 U27.D7
M_B_DQ31: U7.BB3 U27.C2
M_B_DQ32: U7.BG12 U34.A3
M_B_DQ33: U7.BG11 U34.A2
M_B_DQ34: U7.BG17 U34.B8
M_B_DQ35: U7.BJ17 U34.D7
M_B_DQ36: U7.BH12 U34.C2
M_B_DQ37: U7.BJ13 U34.C3
M_B_DQ38: U7.BH18 U34.C8
M_B_DQ39: U7.BH16 U34.A7
M_B_DQ40: U7.BC18 U26.H8
M_B_DQ41: U7.BA18 U26.H7
M_B_DQ42: U7.AU20 U26.E3
M_B_DQ43: U7.AU22 U26.G2
M_B_DQ44: U7.BF18 U26.F7
M_B_DQ45: U7.BD18 U26.F8
M_B_DQ46: U7.AV20 U26.F2
M_B_DQ47: U7.AV22 U26.H3
M_B_DQ48: U7.BF20 U34.H3
M_B_DQ49: U7.BC20 U34.G2
M_B_DQ50: U7.BA22 U34.F8
M_B_DQ51: U7.BD24 U34.H8
M_B_DQ52: U7.BD20 U34.E3
M_B_DQ53: U7.BA20 U34.F2
M_B_DQ54: U7.BF24 U34.F7
M_B_DQ55: U7.BD26 U34.H7
M_B_DQ56: U7.BJ21 U26.D7
M_B_DQ57: U7.BG25 U26.C3
M_B_DQ58: U7.BH20 U26.B8
M_B_DQ59: U7.BG22 U26.A7
M_B_DQ60: U7.BG26 U26.C2
M_B_DQ61: U7.BJ25 U26.A3
M_B_DQ62: U7.BH26 U26.A2
M_B_DQ63: U7.BG21 U26.C8
M_B_DQSN0: U7.AM3 U33.B7
M_B_DQSN1: U7.AV6 U33.G3
M_B_DQSN2: U7.AT13 U27.G3
M_B_DQSN3: U7.BA3 U27.B7
M_B_DQSN4: U7.BG15 U34.B7
M_B_DQSN5: U7.AT20 U26.G3
M_B_DQSN6: U7.BC22 U34.G3
M_B_DQSN7: U7.BG23 U26.B7
M_B_DQSP0: U7.AM2 U33.C7
M_B_DQSP1: U7.AV7 U33.F3
M_B_DQSP2: U7.AT12 U27.F3
M_B_DQSP3: U7.AY2 U27.C7
M_B_DQSP4: U7.BH14 U34.C7
M_B_DQSP5: U7.AT22 U26.F3
M_B_DQSP6: U7.BC24 U34.F3
M_B_DQSP7: U7.BH22 U26.C7
M_B_DRAMRST#: U7.BA12 U26.T2 U27.T2 U33.T2 U34.T2
M_B_ODT0: R1102.2 U7.AV18 U26.K1 U27.K1 U33.K1 U34.K1
M_B_RAS#: R1086.2 U7.BA14 U26.J3 U27.J3 U33.J3 U34.J3
M_B_VREF_CA: U7.AT26
M_B_VREF_DQ: U7.AU26
M_B_WE#: R1095.2 U7.BH10 U26.L3 U27.L3 U33.L3 U34.L3
M_B_ZQ1: R1104.2 U27.L8
M_B_ZQ2: R1076.2 U33.L8
M_B_ZQ3: R1077.2 U34.L8
M_B_ZQ4: R1078.2 U26.L8
MAIND: PC127.2 PQ2.2 PQ4.4 PQ23.3 PQ29.4 PR143.2
MAINON: PQ22.2 PR3.1 PR118.2 PR141.1 PR154.2 PR195.1 PR232.1 R254.1 U9.30
MAINON_ON_G: PQ18.2 PQ20.2 PQ22.3 PQ23.2 PR142.1 PR144.2 Q79.2
MBCLK: PC168.1 PD10.1 PR114.2 PR226.2 R213.1 U9.110
MBCLK2: R216.1 R1023.1 U8.8 U9.115
MBDATA: PC167.1 PD9.1 PR117.2 PR225.2 R212.1 U9.111
MBDATA2: R215.1 R1024.1 U8.7 U9.116
MCSI_COMP: R366.1 U7.P44
MIC2-VREFO: R65.2 R66.2 U4.29
MX0: CN11.1 RP1.1 U9.58
MX1: CN11.2 RP1.2 U9.59
MX2: CN11.3 RP1.3 U9.60
MX3: CN11.4 RP1.4 U9.61
MX4: CN11.5 RP1.6 U9.62
MX5: CN11.6 RP1.7 U9.63
MX6: CN11.7 RP1.8 U9.64
MX7: CN11.8 RP1.9 U9.65
MY0: CN11.26 U9.36
MY1: CN11.25 U9.37
MY2: CN11.24 U9.38
MY3: CN11.23 U9.39
MY4: CN11.22 U9.40
MY5: CN11.21 U9.41
MY6: CN11.20 U9.42
MY7: CN11.19 U9.43
MY8: CN11.18 U9.44
MY9: CN11.17 U9.45
MY10: CN11.16 U9.46
MY11: CN11.15 U9.51
MY12: CN11.14 U9.52
MY13: CN11.13 U9.53
MY14: CN11.12 U9.54
MY15: CN11.11 U9.55
MY16: CN11.10 U9.56
MY17: CN11.9 U9.57
NB670BST: PR35.1 PU3.10
NB670BST_S: PC53.1 PR35.2
NB670CLK: PR18.1 PU3.5
NB670EN: PC52.2 PR168.1 PR169.2 PU3.13
NB670ENLDO: PR34.1 PR167.2 PU3.12
NB670PG: PR24.1 PU3.4
NB670SW: PC53.2 PL3.1 PR164.2 PU3.8 PU3.9 PU3.15 PU3.16
NB671BST: PR59.1 PU5.10
NB671BST_S: PC67.1 PR59.2
NB671EN: PC73.2 PR77.1 PR80.1 PU5.13
NB671FB: PR68.2 PR71.1 PU5.12
NB671PG: PR67.1 PU5.4
NB671SW: PC67.2 PL6.1 PR192.2 PU5.8 PU5.9 PU5.15 PU5.16
NBSWON#: C828.1 CN3.9 R214.1 R816.2 R1158.2 R1166.1
NOVRP1: R1114.1 U35.25
NOVRP2: R1115.1 U35.24
NOVRP3: R1117.1 U35.20
NOVRP4: R1118.1 U35.19
PCBEEP: C34.1 U4.12
PCBEEP_EC: D7.2 R1028.2 U9.34
PCH_AZ_CODEC_BITCLK: C50.2 R202.2 U4.6
PCH_AZ_CODEC_RST#: R206.2 U4.11
PCH_AZ_CODEC_SDIN0: R63.2 U7.AD7
PCH_AZ_CODEC_SDOUT: R208.2 U4.5
PCH_AZ_CODEC_SYNC: R203.2 U4.10
PCH_BLON_EC: R72.2 U9.88
PCH_DISP_ON: Q22.3 R300.1 R384.2 U12.3
PCH_DISP_ON_C: Q22.1 R294.2 U7.R53
PCH_DPST_PWM: Q15.3 R279.1 R382.2
PCH_DPST_PWM_C: Q15.1 R290.2 U7.P52
PCH_EDP_BLON: Q17.3 R71.2 R282.1
PCH_EDP_BLON_C: Q17.1 R280.2 U7.P51
PCH_SLP_S0#: Q33.1 R59.2 R1029.2 U7.D14
PCH_SLP_S0_N: Q33.3 R209.1 R429.1 R1029.1
PCH_SLP_S4#: R247.1 U9.18
PCH_SUSPWRDANCK: PR4.1 Q32.3 R222.1 R420.2 R1199.1
PCH_SUSPWRDANCK_R: R222.2 U9.87
PCIE_CLKREQ1_SSD#: R224.2 U7.AM12
PCIE_CLKREQ2_WLAN#: Q65.1 R225.2 U7.AK14
PCIE_CLKREQ2_WLAN#_R: CN5.53 Q65.3 R598.2
PCIE_CLKREQ3_LAN#: R223.2 U7.AM14
PCIE_RXN2_WLAN: CN5.43 U7.F22
PCIE_RXP2_WLAN: CN5.41 U7.D22
PCIE_TXN2_WLAN: C40.1 CN5.37
PCIE_TXN2_WLAN_C: C40.2 U7.C26
PCIE_TXP2_WLAN: C39.1 CN5.35
PCIE_TXP2_WLAN_C: C39.2 U7.B26
PCIE_WAKE#_R: CN5.55 Q25.1 R331.1
PD#: D9.2 D10.2 R105.2 U4.47
PGANG: R1120.2 U35.23
PHASE_CORE: PC41.1 PL4.1 PQ7.9 PR184.2 PU4.23
PHASE_VGG: PC68.1 PL5.1 PQ6.9 PR182.2 PU6.23
PLL_1P24_PWR: C152.1 C172.1 C180.2 R313.2 U7.AC30 U7.P38 U7.V30
PLLCPU_1P24_PWR: C217.1 C224.2 R395.2 U7.AC36 U7.AD35 U7.AD38 U7.AF35
PLTRST#: Q39.3 R302.2 R408.1 R416.1 R1124.1 U9.22 U13.16
PLTRST#_2: CN5.52 R297.1 R302.1
PMU_BATLOW#: R57.2 U7.C14
PMU_RSMRST#: PR2.1 R177.1
PMU_WIFI_SUSCLK: TP1.1 U7.C15
PROCHOT_EC: Q40.2 R250.2 U9.17
PSELF: R1119.1 U35.22
R_SPK+: R263.1 U4.45
R_SPK+_1: C131.2 CN13.1 R263.2
R_SPK-: R262.1 U4.44
R_SPK-_1: C130.2 CN13.2 R262.2
RAM_ID0: R1180.2 R1181.1 U7.C11
RAM_ID1: R1182.2 R1183.1 U7.B10
RAM_ID2: R1184.2 R1185.1 U7.F12
RAM_ID3: R1186.2 R1187.1 U7.F10
RESET#_USB: C808.2 R1123.1 R1124.2 R1125.2 U35.17
RF_EN: C595.2 R999.2 U9.66
RF_EN_R: CN5.56 R999.1
RING2: L6.1 Q6.3 U4.17
RING2_R: CN6.3 D28.1 L6.2 R66.1
RREF: R1148.1 U23.1
RSMRST#: R166.1 U9.112
RSVD_K20: U7.K20
RSVD_M13: R349.1 U7.M13
RSVD_M20: U7.M20
RTC_3P3A_PWR: C168.1 C170.1 R303.2 R309.2 U7.D4 U7.E3
RTC_X1: C140.2 R304.1 U7.M18 Y3.1
RTC_X2: C141.2 R304.2 U7.K18 Y3.2
S5_ON: PQ3.2 PQ24.2 PQ35.2 PR7.2 PR80.2 PR169.1 R244.2
S5_ON_R: R440.2 R1196.2 U9.100
S5D: PC163.2 PQ17.4 PQ34.3 PR201.2 PR218.2
SATA_GP0: R181.1 U7.AH2
SATA_GP1: R1018.1 U7.AG3
SATA_LED#: R170.2 U7.AH3
SATA_RCOMP_DN: R355.2 U7.M30
SATA_RCOMP_DP: R355.1 U7.N30
SATA_RXN0: C119.2 C831.2 U7.M28
SATA_RXN0_NGFF: C831.1 CN18.43
SATA_RXN0_R: C119.1 CN9.5
SATA_RXP0: C120.2 C832.2 U7.N28
SATA_RXP0_NGFF: C832.1 CN18.41
SATA_RXP0_R: C120.1 CN9.6
SATA_TXN0: C123.2 C829.2 U7.B30
SATA_TXN0_NGFF: C829.1 CN18.47
SATA_TXN0_R: C123.1 CN9.3
SATA_TXP0: C122.2 C830.2 U7.C31
SATA_TXP0_NGFF: C830.1 CN18.49
SATA_TXP0_R: C122.1 CN9.2
SB_ACDC: PR220.2 U9.84
SCL_TO_EC: R1153.1 R1172.1 U9.94
SCL_TO_EC_R: C323.1 R1153.2 R1198.2 U21.4
SD_CD#: R392.2 U23.13
SD_CD#_R: CN16.1 R392.1
SD_CLK: R394.1 U23.15
SD_CLK_R: C816.1 CN16.7 R394.2 R1149.1
SD_CMD: R1145.2 U23.18
SD_CMD_R: C814.1 CN16.4 R1145.1
SD_D0: R388.2 U23.11
SD_D1: R389.2 U23.10
SD_D2: R1146.2 U23.21
SD_D3: R1147.2 U23.20
SD_D4: TP36.1 U23.19
SD_D5: TP53.1 U23.16
SD_D6: TP54.1 U23.14
SD_D7: TP55.1 U23.12
SD_DATA0_R: C818.1 CN16.9 R388.1
SD_DATA1_R: C817.1 CN16.10 R389.1
SD_DATA2_R: C815.1 CN16.2 R1146.1
SD_DATA3_R: C819.1 CN16.3 R1147.1
SD_WP: R390.2 U23.8
SD_WP_R: CN16.11 R390.1
SDA_TO_EC: R1152.1 R1173.1 U9.95
SDA_TO_EC_R: C335.1 R1152.2 R1197.2 U21.6
SDMMC3_COMP: R346.2 U7.P12
SDREG: C423.2 U23.6
SDVO_CLK: Q1.4 R7.2 U7.Y51
SDVO_DATA: Q1.1 R6.2 U7.Y52
SENSEA: R29.1 R41.2 U4.13
SENSOR_EN: R780.2 R782.1 U9.70
SERIRQ: R431.2 U9.5 U16.4
SET1_VCORE: PR39.2 PR176.1 PU4.7
SET1_VGG: PR95.2 PR209.1 PU6.7
SET2_VCORE: PR40.2 PR175.1 PU4.8
SET2_VGG: PR99.2 PR205.1 PU6.8
SET3_VCORE: PR41.2 PR174.1 PU4.9
SET3_VGG: PR88.2 PR203.1 PU6.9
SETGND_VCORE: PC54.2 PR23.1 PR155.1 PR173.1 PR179.2 PR180.1 PR181.2 PU4.30
SETGND_VGG: PC72.2 PR196.1 PR198.1 PR200.1 PR202.2 PR206.1 PR208.2 PU6.30
SIO_EXT_SCI#: U9.23 U18.3
SIO_EXT_SMI#: U9.15 U18.1
SLEEVE: L5.1 Q6.6 U4.18
SLEEVE_R: CN6.4 D27.1 L5.2 R65.1
SLP_A#: R209.2 U9.126
SLP_S0IX#: PR8.1 Q34.1 R307.2 U7.A13
SLP_S3#: PR233.1 Q36.4 R305.2 R451.1 U7.B14
SLP_S4#: Q36.1 Q38.5 R320.2 R453.1 U7.C12
SLP_SUS#_EC: Q34.3 R430.2 U9.19
SMB_RUN_CLK: R432.2 R1190.1 R1198.1 U15.6
SMB_RUN_DAT: R434.2 R1191.1 R1197.1 U15.5
SMB_SOC_ALERTB: R196.2 U7.AM9
SMB_SOC_CLK: R419.2 U7.AM6 U15.3
SMB_SOC_DATA: R418.2 U7.AM7 U15.4
SOC_CLKOUT_0: R112.2 U7.P2
SOC_CLKOUT_1: R120.2 R121.2 U7.R3
SOC_CLKRUN#: R126.2 U7.T3
SOC_DDI1_RCOMP: R341.1 U7.F47
SOC_DDI1_RCOMP_P: R341.2 U7.F49
SOC_DDIO_RCOMP: R342.1 U7.F38
SOC_DDIO_RCOMP_P: R342.2 U7.G38
SOC_DRAM_PWROK: C284.1 R452.2 U7.AV28
SOC_GPIO_RCOMP: R368.2 U7.AH40
SOC_KBC_SCI: R181.2 R499.1 U18.4
SOC_KCB_SMI: R498.1 R1018.2 R1019.2 U18.6
SOC_OVERRIDE_NM: Q16.2 R295.1
SOC_PCIE_COMN: R344.2 U7.F26
SOC_PCIE_COMP: R344.1 U7.D26
SOC_PLTRST#: D22.1 Q39.1 R322.1 U7.F14
SOC_PMC_WAKE: R81.2 U7.N16 U17.4
SOC_PROCHOT#: C86.2 R132.1 R136.2 U7.AD50
SOC_PWRBTN#: R221.1 U7.M16 U17.6
SOC_REST_BTN#: R172.2 U7.AF2
SOC_RSMRST#: R160.2 R166.2 R177.2 U7.F18
SOC_RTEST#: C42.1 G1.1 Q75.3 R38.2 R1209.1
SOC_RTEST#_R: R1209.2 U7.J16
SOC_SERIRQ: R428.2 R431.1 R1013.1 R1200.2 U7.T2 U11.3 U16.3
SOC_SPI_CLK: R75.2 U7.W3
SOC_SPI_CLK_R: R75.1 U5.6
SOC_SPI_CLK_R1: U9.105 U14.6
SOC_SPI_CS#: R96.2 R102.2 U7.V4
SOC_SPI_CS#_R: R96.1 U5.1
SOC_SPI_CS#_R1: R175.2 U9.101 U14.1
SOC_SPI_MISO_R: R85.1 U5.2
SOC_SPI_MISO_R1: R183.1 U9.103 U14.2
SOC_SPI_MOSI_R: R68.1 U5.5
SOC_SPI_MOSI_R1: R218.1 U9.102 U14.5
SOC_USB_OC0#: R99.1 U7.P14 U36.3
SOC_USB_OC1#: R98.1 U1.3 U7.P16
SOC_VCCAPWROK: C286.1 Q35.6 R457.1 U7.AV26
SP7_R: R226.2 U7.AM10
SP14: TP38.1 U23.22
SPD_A0: R174.2 R199.1 U38.1
SPD_A1: R1192.2 R1194.1 U38.2
SPD_A2: R197.1 R1193.2 U38.3
SPD_CLK_SCLK: R1190.2 U38.6
SPD_CLK_SDATA: R1191.2 U38.5
SPI_HOLD#: R184.2 U14.7
SPI_PWR: C100.2 R168.1 R175.1 R176.2 R184.1 R446.1 R1162.1 R1179.2 U14.8
SPI_WP#: R168.2 U14.3
SRT_CRST#: C44.1 Q76.3 R58.2 U7.D18
SUS_PWRDOWNACK: R164.1 R165.2 U7.AE3
SUSB#: PR235.2 PR236.2 Q36.3 R439.1 R441.1 R451.2 R1163.1
SUSC#: Q36.6 R247.2 R453.2 R461.1 R491.1
SUSD: PC142.2 PQ31.3 PQ32.2 PR178.2 PR186.2
SUSON: PQ30.2 PR121.2 R210.1 U9.120
SUSPWRDANCK: Q32.1 R163.2 R164.2 R420.1
SUSPWRDANCK_EC: PR133.1 U9.80
SVID_ALERT#_SOC: R142.2 R143.1 U7.AD40
SVID_CLK_SOC: R147.1 R148.1 U7.AD42
SVID_DATA_SOC: R138.2 R139.1 U7.AD41
SYS_HWPG: D18.1 PR24.2 PR67.2 PR156.2 R1195.2 U9.20
SYS_SHDN#: PQ16.3 PR77.2 PR157.1 PR168.2 R1204.2
TEMP_MBAT: PR223.1 PR227.2 U9.73
THER_CPU: R69.2 R78.1
THERMDA: TP6.1 U8.2
THERMDC: TP5.1 U8.3
THRM_MOINTOR: C51.2 R78.2 R79.1 R255.2
TON_VCORE: PR37.2 PU4.16
TON_VGG: PR193.2 PU6.16
TOUCH_SCREEN_PWR: C71.2 C73.1 CN10.10 CN10.11 R129.1 R130.1
TP_EN_EC: C594.1 R587.1 U9.78
TP_EN_EC_C: CN12.8 R587.2
TP_INT#: Q42.3 R39.1 U7.E8
TP_INT_C: R80.1 U7.J12
TP_INT_EC#: Q44.3 R435.1 R505.1 U9.128
TP_POWER_ON: R497.1 R1157.1 R1167.1
TP_RST#_Q: R101.1 U7.F7
TP_SENSOR_INT_C: CN12.7 R588.2
TP_SENSOR_INT_R: C320.1 Q41.2 Q44.1 R495.1 R505.2 R588.1
TPCLK: C330.2 CN12.2 R513.2 U9.89
TPDATA: C329.2 CN12.3 R512.2 U9.90
TPM_SERIRQ: R1013.2 U11.4 U13.27
TPM_VDD: C91.1 C95.1 C97.1 C98.1 C99.1 R135.2 R159.2 R396.1 R399.2 R1201.1 U11.6 U13.10 U13.19 U13.24
TPM_VSB: C92.2 C94.1 R149.2 R159.1 U13.5
TS_EN: C596.2 R1000.1 U9.81
TS_EN_R: CN10.35 R1000.2
TS_USB+: R118.1 U35.7
TS_USB+_I2CCL: CN10.30 R118.2
TS_USB-: R119.1 U35.6
TS_USB-_I2CDA: CN10.31 R119.2
TSEN_VCORE: PC54.1 PR50.2 PR173.2 PU4.11
TSEN_VGG: PC72.1 PR198.2 PR199.2 PU6.11
UART1_RXD: TP30.1 U7.AD12
UART1_TXD: TP32.1 U7.AD10
UGATE_VCORE: PQ7.1 PU4.25
UGATE_VGG: PQ6.1 PU6.25
ULT_EDP_HPD: C698.1 Q10.2 R378.2 R819.1
USB2_1P24_PWR: C153.2 C162.2 R312.1 U7.H44
USB2_OBSP: R333.1 U7.B46
USB3_OBSN: R343.2 U7.F34
USB3_OBSP: R343.1 U7.D34
USB30_RX0+: R12.2 U7.F28
USB30_RX0+_R: CN1.6 D26.1 R12.1
USB30_RX0-: R11.2 U7.D28
USB30_RX0-_R: CN1.5 D25.1 R11.1
USB30_TX0+: C21.1 U7.B32
USB30_TX0+_C: C21.2 R14.2
USB30_TX0+_R: CN1.9 D24.1 R14.1
USB30_TX0-: C20.1 U7.C32
USB30_TX0-_C: C20.2 R13.2
USB30_TX0-_R: CN1.8 D23.1 R13.1
USB_1P8_PWR: C218.1 C256.1 R423.1 U7.AA29
USB_1P24_PWR: C149.2 C156.2 R314.1 R315.1 U7.U35 U7.V35
USB_3P3_PWR: C43.1 R49.1 U7.B22 U7.C23
USB_CAR_N: R1140.2 R1143.2 U23.2
USB_CAR_P: R1141.2 R1142.2 U23.3
USB_CR_N: R1140.1 U35.15
USB_CR_P: R1141.1 U35.16
USB_HSIC_RCOMP: R352.2 U7.N38
USB_HUB_5V: TP48.1 U35.27
USB_HUB_N: R1136.2 U35.1
USB_HUB_P: R1137.2 U35.2
USB_RCOMP: R60.2 U7.A48
USB_VBUSSNS: R61.1 R62.1 U7.B47
USBHSIC_1P24_PWR: C183.2 R338.1 U7.M41
USBON#: R256.1 U1.4 U36.4
USBP0+: R15.2 U7.C42
USBP0+_R: CN1.3 D2.1 R15.1
USBP0-: R16.2 U7.B42
USBP0-_R: CN1.2 D3.1 R16.1
USBP1+: CN3.7 U7.C43
USBP1-: CN3.6 U7.B44
USBP2+: R1137.1 R1139.1 U7.C41
USBP2-: R1136.1 R1138.1 U7.A41
USBP2_CAR_N: R1138.2 R1143.1
USBP2_CAR_P: R1139.2 R1142.1
USBP3+: R109.2 U7.C45
USBP3+_R: CN10.27 R109.1
USBP3-: R106.2 U7.A45
USBP3-_R: CN10.28 R106.1
USBP4+: CN5.3 U7.B40
USBP4-: CN5.5 U7.C40
USBSSIC_1P05_PWR: C158.2 C166.2 R323.1 U7.V29
USBSSIC_1P24_PWR: C194.2 R347.1 U7.P41
V_BLIGHT: C201.2 C202.1 C213.1 CN10.1 CN10.2 R405.2 R406.2
VA1: PC1.2 PC5.2 PC10.1 PC115.2 PD3.2 PD4.1 PJ1.1 PQ1.1 PQ15.1 PQ15.2 PQ15.3 PR1.1
VA2: PD5.1 PD5.2 PQ15.5
VCLK_VCORE: PR44.2 PU4.15
VCLK_VGG: PR69.2 PU6.15
VCORE_PWRGD: D20.1 PR38.2 PR52.1 PR237.2
VDIO_VCORE: PR42.1 PU4.13
VDIO_VGG: PR76.1 PU6.13
VGG_PWRGD: D21.1 PR58.1 PR65.1 PR234.1
VGG_SENSEN: PR210.1 R188.1
VGG_SENSEN_R: R188.2 U7.AD22
VGG_SENSEP: PR213.1 R191.1
VGG_SENSEP_R: R191.2 U7.AD24
VGPU_EN: TP28.1 U7.Y7
VL: PC51.2 PR14.1 PR15.1 PR145.2 PU3.11
VNN_REFIN_R: R169.2 U7.AC27
VOL_DN#: CN3.11 U9.47
VOL_UP#: CN3.10 U9.124
VR_READY_VCORE: PR38.1 PU4.17
VR_READY_VGG: PR65.2 PU6.17
VR_SVID_ALERT#: PR36.1 PR73.1 R143.2
VR_SVID_CLK: PR44.1 PR62.2 PR69.1 PR187.2 R148.2
VR_SVID_DATA: PR42.2 PR76.2 PR79.1 PR188.1 R139.2
VRON_VCORE: PC135.2 PR154.1 PR234.2 PR235.1 PU4.26
VRON_VGG: PC154.2 PR195.2 PR236.1 PU6.26
WAKE_SRC_1: R231.2 R351.1 U17.3
WIFI_SUSCLK: CN5.50 TP46.1
WLAN_WAKE#: R235.1 R360.1 U9.16
WRST#: C290.1 D16.2 R468.1 R1038.1 U9.14
XD_CD#: TP50.1 U23.7
XD_D7: TP37.1 U23.23
XD_RE#: TP51.1 U23.9
XDP_H_PRDY#: TP33.1 U7.AD45
XDP_H_PREQ#: R356.1 U7.AF41
XDP_H_TCK: R409.1 U7.AF42
XDP_H_TDI: R115.1 U7.AD47
XDP_H_TDO: R357.1 U7.AF40
XDP_H_TMS: R358.1 U7.AD48
XDP_H_TRST#: R113.2 U7.AB48
XIN: C807.1 U35.10 Y4.1
XOUT: C806.1 U35.11 Y4.3
XTAL25_IN: C139.1 R311.1 U7.P24 Y2.3
XTAL25_OUT: C138.1 R311.2 U7.M22 Y2.1
N16512880: R182.1 U8.4
N18086472: LED2.2 R266.1
N18086480: LED2.1 R267.1
N18134434: D7.1 D8.1 R25.2
N18218785: C225.1 C226.2 C231.2 C232.1 C233.2 R385.1 U12.1
N18853812: C36.1 R67.2 U4.27
N19249672: C316.2 R496.2 U19.7 U19.8
N19667233: R399.1 R403.1 U13.7
N19667243: R396.2 U13.6
N19667397: R415.2 R1201.2 U13.15
N19667450: TP23.1 U13.1
N19667455: TP27.1 U13.2
N19667489: R408.2 R1012.2 U13.9
N19667717: TP25.1 U13.28
N19837103: Q41.3 Q42.2 R493.1
N20065575: D22.2 R490.2 U20.K5
N20159060: Q5.2 R71.1 R72.1 R73.2
N20159096: C17.1 D5.1 MR1.1 R17.1
N20218729: R401.2 U11.5
N20310085: C76.2 Q7.2 R124.2 R125.1
N20824488: R220.1 R232.1 U17.5
N21039756: C75.2 Q27.2 R128.1 R376.2
N21041656: R514.2 U21.7
N21053283: Q25.3 R351.2 R360.2
N21085249: PD5.3 PR135.2 PR136.1
N21086309: PC10.2 PQ1.6 PQ15.4 PR1.2 PR5.1
N21086343: PQ10.4 PR229.2 PR230.1
N21086349: PQ1.2 PQ1.3
N21086359: PQ1.5 PQ37.2 PR10.2
N21086370: PL7.1 PR96.1 PR113.1
N21086453: PC81.1 PR86.2
N21086471: PJ2.3 PR225.1
N21086542: PJ2.4 PR226.1
N21086566: PC96.2 PD2.1 PR109.1
N21086652: PD3.1 PR122.1 PR127.2
N21086663: PR126.1 PR127.1
N21086667: PR117.1 PU8.8
N21086672: PR114.1 PU8.9
N21086756: PR101.2 PU8.13
N21086758: PR100.2 PU8.12
N21086804: PQ37.3 PR230.2
N21086812: PQ11.3 PR105.1
N21086823: PQ36.2 PQ36.5 PR125.1 PU8.5
N21086841: PQ36.6 PR221.1 PR222.2
N21086931: PJ2.5 PR227.1
N21092228: PL1.1 PU1.22 PU1.23
N21092230: JP2.1 PC2.1 PC3.1 PC4.1 PC12.1 PC13.1 PL1.2 PU1.19
N21092239: PR2.2 PR6.2 PU1.13
N21092313: JP3.1 PC15.1 PC16.1 PC17.1 PC118.1 PC119.1 PL2.2 PU1.3
N21092367: PC11.1 PU1.16
N21092424: JP1.1 PC6.1 PC7.1 PC8.1 PU1.20 PU1.21
N21092523: C702.1 PR7.1 PU1.26
N21092531: PR3.2 PR8.2 PU1.25
N21092542: PR4.2 PR133.2 PU1.24 R317.2
N21092547: PR134.2 PR232.2 PR233.2 PU1.4
N21094638: PC85.1 PR90.1
N21094642: PC87.2 PR90.2 PU7.5
N21094874: JP8.1 PC131.2 PC136.2 PC137.2 PC173.2 PC174.2 PC175.2 PC176.2 PL8.2 PR132.1
N21094973: PC171.2 PR231.1
N21097743: PC24.1 PC37.1 PR19.2 PR20.2 PR25.2
N21097745: PR153.2 PR155.2 PU4.29
N21097753: PC48.1 PC129.1 PR29.2 PR33.2 PR147.1 PR148.2
N21097757: PR21.2 PR22.2
N21097815: PC56.2 PR37.1 PR51.2
N21097880: PC48.2 PR32.2
N21097916: PC43.2 PR30.1
N21098033: PR45.2 PR50.1 PR177.1
N21098047: PR49.1 PU4.10
N21098063: PR29.1 PU4.4
N21098069: PR39.1 PR46.1
N21098076: PR176.2 PR181.1
N21098081: PR40.1 PR47.2
N21098093: PR175.2 PR180.2
N21098098: PR41.1 PR48.2
N21098107: PR174.2 PR179.1
N21098112: PC60.1 PR46.2 PR47.1 PR48.1 PR54.1 PR55.2
N21098137: PR27.2 PU4.24
N21098141: PR27.1 PU4.18
N21098147: PR158.1 PR159.1
N21098149: PC34.1 PR158.2 PU4.31
N21098151: PR160.1 PR161.1
N21098153: PR152.1 PR159.2 PR160.2
N21098161: PR151.1 PR152.2
N21098163: PR26.1 PR151.2
N21098205: PR163.1 PR165.1
N21098274: PL4.4 PR19.1
N21098278: PL4.3 PR22.1
N21098343: PC41.2 PR31.1
N21100012: PR61.2 PR63.1
N21100035: PC70.1 PC71.1 PR60.2 PR72.2 PR74.2
N21100086: PC89.1 PC162.1 PR93.2 PR213.2 PR214.2 PR216.1
N21100137: PC89.2 PR106.2
N21100164: PC83.2 PR98.1
N21100271: PR53.2 PR185.1 PR199.1
N21100284: PR82.1 PU6.10
N21100302: PR93.1 PU6.4
N21100314: PR99.1 PR103.2
N21100326: PR95.1 PR107.2
N21100328: PR88.1 PR89.2
N21100340: PC160.1 PR87.2 PR89.1 PR103.1 PR107.1 PR207.1
N21100369: PR64.2 PU6.24
N21100377: PR84.1 PR85.2 PR94.2
N21100379: PR81.1 PR94.1
N21100381: PC76.1 PR78.2 PU6.31
N21100383: PR78.1 PR85.1
N21100387: PR64.1 PU6.18
N21100399: PR28.1 PR83.2
N21100401: PR83.1 PR84.2
N21100433: PR75.2 PR196.2 PU6.29
N21100449: PR212.1 PR215.1
N21100533: PL5.3 PR61.1
N21100556: PL5.4 PR60.1
N21100764: PC153.2 PR191.2 PR193.1
N21100901: PC68.2 PR56.1
N21102302: PR15.2 PR16.1 PU2.2
N21102304: PC20.2 PR11.1 PR12.1 PU2.8
N21102308: PD1.1 PQ21.1 PR17.1
N21102320: PQ21.3 PR12.2
N21102324: PQ21.2 PQ24.3 PR17.2
N21102361: PC117.2 PQ16.2 PR11.2 PU2.1
N21102373: PQ3.3 PR16.2
N21102766: PR138.2 PR238.2 Q79.3
N21102772: PQ18.3 PR137.2
N21102817: PQ20.3 PR139.2
N21108515: C317.1 C318.2 Q45.1 R501.2 R507.2 R510.1
N21108595: C318.1 Q45.2 R497.2
N21125286: R427.1 U16.5
N21132627: C61.1 C64.1 C67.1 C68.1 L8.2 U4.41 U4.46
N21260714: Q31.2 R400.1 R407.2
N21264338: R74.2 U4.4
N21358530: PQ27.2 PQ30.3 PQ31.2 PR189.1 PR190.2
N21358603: PQ27.3 PR183.2
N21362550: R494.1 U7.T13
N21395083: R100.1 U7.P13
N21417954: R45.2 U7.B53
N21417957: R44.2 U7.A52
N21604905: JP7.1 PC74.2 PC77.1 PC88.1 PC99.1 PC157.1 PC158.2 PU5.1
N21665898: R278.1 R280.1 R290.1 R294.1
N21685145: PC69.2 PU5.11
N22167393: C126.1 Q13.2 Q13.3 R257.2 R259.2
N22167500: Q13.6 R1037.2 R1038.2
N22770206: C33.2 R46.1 R62.2
N23050514: CN9.10 R1020.1 R1021.1
N23242231: R1014.2 U4.20
N23537790: PD6.2 PR145.1 PR146.2
N23537831: PC32.2 PC132.2 PC134.2 PR18.2
N23562987: R340.1 U7.G18
N23981964: R50.1 U7.A3
N24050420: Q65.2 R671.1
N24425848: C438.2 U23.24
N24510304: CN18.2 CN18.4 CN18.70 CN18.72 CN18.74 R1150.1
N24601108: TP8.1 U9.113
N24628331: C839.1 Q54.2 R780.1
N24651621: R169.1 T5.1
N24658073: TP63.1 U9.71
N24658281: TP64.1 U9.69
N24794497: CN11.27 D42.1 R816.1
N24883800: R1196.1 U37.3
N24951133: R1188.2 R1189.2 U38.7
N24952012: C275.2 R433.2 U15.7 U15.8
N25329235: CN16.15 R1202.2
N25329238: CN16.14 R1203.2
N25638274: Q21.3 Q23.2 R299.2
N25841079: C874.2 Q77.2 Q78.3 R1205.2
N26412554: JP10.1 PC45.1 PC46.2 PC47.1 PC139.1 PC140.2 PU3.1
N26412705: PC138.2 PR164.1
N26422980: PR70.1 PU5.3
N26423000: JP11.1 PC49.1 PC55.1 PC57.1 PC58.1 PC61.1 PC62.1 PL6.2 PR68.1 PU5.7
N26432389: PC32.1 PD6.3
N26432391: PC128.2 PD6.1 PD7.2
N26432399: PC132.1 PD7.3
N26432434: PC134.1 PD8.3
N26432450: PC130.2 PD7.1 PD8.2
N26432481: PC133.2 PD8.1 PR162.2
N26437430: PQ33.2 PQ34.2 PQ35.3 PR217.2 PR219.1
N26437470: PQ33.3 PR194.2
N102802469: C117.2 R249.1
N107989610: C49.1 U4.7
N107992729: C62.2 U4.39
N107992826: C57.2 U4.35
N107992865: C57.1 U4.37
N107994632: C52.1 U4.34
N107996449: C45.2 U4.28
N108778749: Q6.2 Q6.5 Q7.3 R107.1
N111127099: C26.1 U4.19
N112543597: D16.1 R468.2 R1175.1
N112543691: C292.1 U9.12
N112544291: TP61.1 U9.117
N112544352: TP60.1 U9.24
N112544364: TP59.1 U9.28
N112550518: TP62.1 U9.48
N241867701: PC155.2 PR192.1
N241897731: PC146.2 PR184.1
N241913881: PR205.2 PR206.2
N241915201: PR208.1 PR209.2
N241918500: PR202.1 PR203.2
N241918800: PC145.2 PR182.1

Pads without a net: CN2 13 14; CN5 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 65 67 76 77; CN9 20 21 22; CN10 3 4; CN13 5 6; CN16 12 13; CN18 6 7 8 9 10 11 20 21 22 23 24 25 26 28 29 30 31 32 34 35 36 37 38 40 42 44 46 48 50 52 53 54 55 56 58 59 60 61 62 63 64 65 66 67 68 76 77; NOREF#2 1; NOREF#3 1; NOREF#5 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; PU2 7; PU3 3; PU4 32; PU5 5 6; PU6 32; U4 14 15 16 23 24 48; U7 A17 A21 A25 A27 A29 A33 A35 A37 A49 A51 AA51 AB7 AB9 AB40 AB41 AB44 AB45 AB51 AB52 AC53 AD6 AF3 AF44 AF45 AF48 AF50 AH45 AK9 AK12 AK13 AK41 AK42 AK48 AM40 AM41 AM44 AM45 AM47 AM48 AT24 AT30 AU16 AU24 AU30 AU38 AY12 AY42 B12 B16 B20 B24 B34 B38 B48 B49 B50 BA16 BA38 BD16 BD38 BF16 BF38 C16 C17 C19 C21 C24 C25 C27 C29 C33 C34 C35 C37 C38 C49 C53 D2 D6 D12 D20 D30 D36 D44 D48 D52 E52 E53 F2 F20 F30 F36 F40 F42 F44 G2 G20 G24 G32 G34 G36 G40 G42 G44 H3 H5 H7 H46 H47 J1 J3 J14 J20 J24 J26 J28 J32 J34 J36 J40 K2 K3 K6 K7 K9 K10 K26 K28 K38 K40 K44 K47 K48 L3 L51 L53 M10 M12 M26 M32 M34 M36 M38 M44 M47 M48 M51 M52 N26 N34 N36 P18 P26 P28 P30 P34 P45 P47 P48 P50 T41 T42 T44 T45 T48 T50 T51 T52 U51 V6 V7 V12 V13 V14 V45 V47 V48 V50 V51 V52 W53 Y3 Y12 Y13 Y41 Y47 Y48; U9 2 3; U13 3 8 12 13 14; U20 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E12 E13 E14 F1 F2 F3 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U21 2 3; U24 J1 J9 L1 L9; U25 J1 J9 L1 L9; U26 J1 J9 L1 L9; U27 J1 J9 L1 L9; U31 J1 J9 L1 L9; U32 J1 J9 L1 L9; U33 J1 J9 L1 L9; U34 J1 J9 L1 L9; U35 3 4 12 13; U37 4

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3118 vias
v2: diameter 0.61, hole 0.356, TOP to BOTTOM, 287 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 437 vias
v4: diameter 0.66, hole 0.33, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
2.469V: length 5.6
  BOTTOM w0.254: PR14.2 112.52,39.2 v1(112.52,38.78) 112.52,37.95 PR13.1 113.04,37.95 113.62,38.53 114.65,38.53 115.06,38.12 115.06,37.11
5V_HSMBCK: length 1.8
  BOTTOM w0.102: R269.1 17.9,84.53 18.29,84.14 D14.1
5V_HSMBDT: length 1.7
  BOTTOM w0.102: D13.1 18.26,82.23 18,81.97 R268.1
5VUSB_0:
  vias: v1(16.64,61.1) v2(14.42,63.52) v2(14.42,62.75) v2(19.36,58.72) v2(20.27,58.56)
5VUSB_1:
  vias: v1(155.68,101.72)
51216VBST: length 3
  BOTTOM w0.203: 30.42,51.41 30.48,51.35 PU7.15
  BOTTOM w0.508: PR120.2 28.84,52.99 v1(29.66,52.17) 30.42,51.41
51216VBST_S: length 1.7
  BOTTOM w0.508: PR120.1 v1(28.62,50.87) 28.62,50.65 28.54,50.56 PC105.1
51216VDDQSNS: length 2.2
  BOTTOM w0.203: PU7.9 31.58,48.16 31.41,47.99
  BOTTOM w0.254: PR132.2 30.48,47.06 31.41,47.99
