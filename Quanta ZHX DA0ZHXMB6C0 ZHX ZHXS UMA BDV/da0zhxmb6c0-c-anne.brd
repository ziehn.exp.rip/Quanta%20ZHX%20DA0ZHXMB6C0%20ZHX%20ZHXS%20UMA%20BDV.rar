# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5V: length 358
  TOP w0.203: U4.9 12.27,18.8 13.04,19.56 C38.1
  TOP w0.457: C38.1 C35.1 14.75,19.56 v1(14.85,19.47)
  TOP w0.508: v1(53.32,100.32) 53.32,97.9 51.79,96.37 51.79,94.46 51.41,94.07 48.06,94.07 47.4,94.73 37.42,94.73 35.79,93.11 32.95,93.11 31.33,94.73 28.2,94.73 26.87,93.41 25.02,93.41 23.7,94.73 18.54,94.73 18.12,95.15 17.44,95.15 16.92,95.67 15.44,95.67 14.95,95.18 14.95,91.66 13.13,89.84 v1(13.13,86.76) ; v1(14.3,61.26) 14.3,54.37 15.34,53.33 16.72,53.33 19.79,50.26 19.79,44.08 20.35,43.53 20.35,40.97 20.69,40.62 20.69,36.4 19.96,35.67 17.67,35.67 17.17,35.17 v1(17.17,32.25) v1(18.18,31.24) ; v1(125.53,68.58) 125.77,68.58 v1(126.74,69.55) 127.47,70.28 127.47,71.79 126.24,73.02 126.24,74.95 125.16,76.03 125.16,79.18 122.16,82.18 122.16,86.21 120.31,88.06 v1(120.31,90.92) 120.69,91.3 120.69,94.34 117.32,97.7 117.32,98.7 116.16,99.87 116.16,101.95 v1(117.02,102.81) ; Q11.2 29.08,24.35 28.63,24.81 28.63,28.13 29.66,29.16 30.81,29.16 30.93,29.04 31.83,29.04 32.26,29.47 v1(32.26,29.78) ; v1(98.4,63.21) 98.27,63.08 96.7,63.08 96.03,63.75 95.42,63.75 94.83,64.35 94.83,65.64 R402.1 ; v1(14.98,30.09) R125.2 ; L7.2 9.16,8.93 v1(9.24,8.85)
  IN1 w0.508: v1(32.26,29.78) 32.26,29.91 31.83,30.34 30.68,30.34 29.71,31.32 23.28,31.32 21.98,32.62 19.56,32.62 v1(18.18,31.24) 17.53,30.58 16.36,30.58 15.86,30.09 v1(14.98,30.09) ; v1(120.31,90.92) 119.04,89.65 119.04,89.64 114.51,89.64 113.46,90.69 104.94,90.69 104.02,91.61 101.06,91.61 99.3,93.37 99.3,96.42 98.18,97.54 97.19,97.54 95.95,98.78 95.95,102.48 95.61,102.83 95.61,103.57 94.49,104.69 94.49,106.46 93.63,107.32 89.28,107.32 v1(87.55,105.59) ; v1(125.53,68.58) 123.11,68.58 121.9,67.38 114.76,67.38 111.85,64.47 110.68,64.47 109.69,65.46 109.69,67.19 107.74,69.14 103.53,69.14 100.94,66.54 100.51,66.54 100.14,66.17 98.69,66.17 98.31,65.79 98.31,65.25 98.51,65.05 98.51,63.33 v1(98.4,63.21)
  IN2 w0.508: v1(53.32,100.32) 53.56,100.56 60.01,100.56 62.92,103.47 64.06,103.47 64.54,103.95 65.61,103.95 v1(66.02,104.36) ; v1(14.3,61.26) 15.11,61.26 18.11,64.25 18.53,64.25 21.29,67.01 21.29,71 18.5,73.78 14.53,73.78 13.64,72.89 12.45,72.89 11.81,73.52 11.81,85.08 13.13,86.4 v1(13.13,86.76)
  BOTTOM w0.203: PU1.10 116.57,102.14 116.75,102.33 117.41,102.33 PC19.1
  BOTTOM w0.508: v1(66.02,104.36) 66.14,104.36 66.24,104.26 67.85,104.26 68.66,105.07 81.65,105.07 82.23,104.49 84.1,104.49 84.83,105.21 85,105.25 87.21,105.25 v1(87.55,105.59) ; 14.16,18.91 11.8,16.55 11.8,12.42 10.34,10.96 10.34,9.95 v1(9.24,8.85) ; 13.71,19.74 13.71,20.66 14.96,21.91 14.96,27.57 14.23,28.31 14.23,29.33 v1(14.98,30.09) ; v1(117.02,102.81) 117.74,102.81 PC19.1
+1.05V_S5: length 211.3
  TOP w0.381: v1(71.77,71.28) 71.93,71.12 C206.1
  TOP w0.508: v1(33.25,67.68) 33.67,67.68 PR187.1 PC147.2 33.93,64.06 35.97,62.02 35.98,62.02 36.16,61.84 36.16,60.85 35.65,60.34 35.65,56.96 v1(35.85,56.75) ; v1(122.68,67.12) 122.68,68.01 124.29,69.61 124.29,71.28 124.85,71.84 124.85,72.66 124.36,73.15 123.83,73.15 123.55,73.43 v1(123.55,74.03) ; R425.2 R426.2 C143.2 94.45,62.03 95.3,62.88 C205.2 96.01,62.88 96.47,62.42 98.68,62.42 v1(98.93,62.68) ; PR79.2 PR197.1 PR62.1 PC156.2 130.17,55.8 130.44,55.8 v1(131.09,56.45) ; 60.15,89.98 59.41,89.25 58.65,89.25 58.02,89.87 58.02,93.2 56.19,95.04 v1(53.6,95.04)
  IN1 w0.508: v1(33.25,67.68) 32.6,68.33 32.6,68.96 31.93,69.64 31.93,70.55 30.89,71.59 30.89,72.49 28.12,75.26 28.12,79.92 29.55,81.36 29.55,85.68 32.21,88.33 33.68,88.33 39.34,94 50.21,94 51.25,95.04 v1(53.6,95.04) ; v1(131.09,56.45) 131.45,56.81 131.65,56.81 132.31,57.47 132.31,59.61 132.74,60.05 132.74,66.87 132.27,67.34 125.84,67.34 125.64,67.54 123.1,67.54 v1(122.68,67.12) 122.29,66.73 115.02,66.73 114.73,66.44 114.73,66.44 112.12,63.82 110.41,63.82 109.33,64.91 108.23,64.91 106.86,66.28 101.91,66.28 101.52,65.9 100.83,65.9 99.16,64.23 99.16,62.91 v1(98.93,62.68) ; v1(123.55,74.03) 123.55,73.79 123.09,73.33 122.58,73.33 121.13,74.78 120.34,74.78 119.76,75.36 119.76,77.26 118.99,78.03 117.75,78.03 117.19,78.59 114.95,78.59 113.1,80.44 109.62,80.44 108.22,81.84 106.14,81.84 105.54,81.24 104.5,81.24 104.24,81.51 101.14,81.51 100.32,82.33 99.6,82.33 96.48,85.44 v1(95.15,85.44)
  BOTTOM w0.381: PR188.2 PR171.1 33.5,67.44 v1(33.25,67.68)
  BOTTOM w0.508: R147.2 R142.1 R138.1 C182.2 46.36,67.77 48.19,65.95 48.19,65.68 49.91,63.97 49.91,59.72 46.85,56.66 39.61,56.66 39.55,56.73 35.88,56.73 v1(35.85,56.75)
  vias: v1(65.1,89.78) v1(66.9,89.88) v1(67.01,90.97) v1(69.11,85.26) v1(69.52,84.75) v1(70.18,91.63) v1(70.95,91.2) v1(72.52,72.08) v1(73.28,73.62) v1(74.05,72.07) v1(74.85,72.85) v1(74.81,72.07) v1(75.57,72.07) v1(76.32,92.12) v1(77.11,92.17) v1(77.22,90.92) v1(77.78,92.17) v1(77.88,90.92) v2(94.24,93.94) v2(94.24,93.18) v2(95,93.94) v2(95,93.18) v2(95.76,93.94) v2(95.76,93.18) v2(96.52,93.94) v2(96.52,93.18) v2(97.28,93.97) v2(97.28,93.18)
+1.5VA: length 6.9
  TOP w0.203: U4.40 7.59,14.08 6.91,13.4 6.91,12.62 C65.1
  TOP w0.508: L7.1 7.96,10.25 v1(7.57,10.63) 7.29,10.63 6.99,10.34 C880.1 6.51,10.61 C69.1 C65.1
+1.8V: length 373.8
  TOP w0.254: R671.2 143.77,85.18 144.89,85.18 v1(144.92,85.21) ; R6.1 19.1,84.87 Q1.2 ; Q1.5 19.1,80.67 R7.1
  TOP w0.508: v1(81.84,102.2) 81.51,101.87 81.51,100.94 81.87,100.58 81.87,96.89 82.35,96.42 83.29,96.42 84.81,94.89 84.81,92.27 84.27,91.73 84.27,91.1 84.75,90.62 86.06,90.62 87.83,88.84 v1(87.83,88.41) 87.83,85.74 88.04,85.53 88.04,84.6 87.61,84.17 87.44,84.17 R1127.1 87.59,83.45 v1(87.94,83.45) ; PR139.1 105.21,81.45 105.21,76.68 107.01,74.88 v1(107.02,74.88) 109.09,76.95 109.09,77.38 111.05,79.34 113.56,79.34 113.81,79.09 R503.1 114.56,79.48 114.56,80.99 115.17,81.6 116.97,81.6 117.53,81.04 117.53,79.62 118.31,78.84 R500.1 ; v1(69.67,102.56) 69.7,102.58 70.35,102.58 R227.1 ; R7.1 19.89,80.07 20.27,80.45 v1(20.29,80.45) ; v1(129.9,68.27) 130.95,68.27 131.73,67.49 132.16,67.49 133.33,66.32 134.35,66.32 134.69,66.66 136.46,66.66 136.82,66.29 136.82,62.36 137.46,61.73 139.14,61.73 139.57,62.16 143.17,62.16 144.99,63.99 147.54,63.99 148.1,63.43 148.1,61.11 148.59,60.63 149.42,60.63 149.89,60.16 Q53.2 ; R6.1 18.92,86.44 v1(18.54,86.81) ; R1028.1 20.08,40.37 19.73,40.71 19.73,43.27 19.18,43.83 19.18,50 v1(17.01,52.17) ; v1(130.18,84.78) 130.15,84.78 129.12,83.75 129.12,78.97 130.58,77.52 130.58,73.26 129.13,71.82 v1(129.13,70.3) ; R201.1 90.56,70.58 v1(90.35,70.58) 90.16,70.58 R170.1
  IN1 w0.508: v1(130.18,84.78) 130.2,84.78 130.68,84.3 140.47,84.3 141.38,85.21 v1(144.92,85.21) ; v1(129.13,70.3) 128.29,69.46 126.38,69.46 126.05,69.79 v1(123.6,69.79) ; v1(87.94,83.45) 87.66,83.45 87.25,83.05 87.25,81.48 89.69,79.04 92.98,79.04 93.63,78.39 95.07,78.39 99.47,73.99 103.1,73.99 103.99,74.88 v1(107.02,74.88) 107.44,74.45 107.44,73.56 111.48,69.52 v1(114.94,69.52) ; v1(17.01,52.17) 17.46,52.61 17.46,56.44 16.07,57.83 16.07,59.32 18.79,62.03 20.92,62.03 21.41,62.52 21.41,64.8 22.98,66.36 22.98,71.68 18.87,75.78 18.87,79.04 v1(20.29,80.45) 18.54,82.19 v1(18.54,86.81) 17.83,86.81 17.35,87.29 17.35,91.28 22.56,96.48 28.6,96.48 30.7,94.39 33.97,94.39 v1(34.24,94.66) 34.86,94.66 37.8,97.6 45.83,97.6 46.99,98.76 52.72,98.76 55.17,101.21 60.61,101.21 61.72,102.33 69.44,102.33 v1(69.67,102.56) 80.11,102.56 80.47,102.2 v1(81.84,102.2) 81.87,102.23 82.3,102.23 83.62,103.55 85.53,103.55 86.46,104.48 v1(86.51,104.48) ; v1(90.35,70.58) 91.42,71.64 94.79,71.64 95.94,70.5 97.21,70.5 98.65,71.94 106.56,71.94 110.75,67.75 v1(112.42,67.75)
  IN2 w0.508: v1(123.6,69.79) 122.19,69.79 121.57,70.41 120.24,70.41 119.94,70.11 115.5,70.11 114.94,69.54 v1(114.94,69.52) 114.91,69.52 114.41,69.02 113.67,69.02 112.42,67.77 v1(112.42,67.75) ; v1(129.13,70.3) 129.13,69.51 129.9,68.75 v1(129.9,68.27)
  BOTTOM w0.254: 129.51,82.29 129.52,82.28 U11.1
  BOTTOM w0.305: v1(130.18,84.78) 130.18,84.65 128.99,83.46 R401.1 128.99,83.27 129.51,82.75 129.51,80.75 129.77,80.48 130.43,80.48 130.65,80.26 R1200.1
  BOTTOM w0.508: 95.25,102.43 95.25,103.01 92.67,105.59 88.42,105.59 87.47,104.63 86.66,104.63 v1(86.51,104.48) ; R490.1 107.01,75.61 107.01,74.88 v1(107.02,74.88) ; R19.2 17.91,86.57 18.15,86.81 v1(18.54,86.81) ; v1(34.24,94.66) 34.24,94.61 34.46,94.39 35.32,94.39 Q15.2 36.09,94.38 36.12,94.4 Q22.2 37.03,91.48 37.26,91.25 38.25,91.25 38.76,90.74 Q17.2
+1.8V_EMMC: length 1.9
  BOTTOM w0.254: U20.N4 U20.M4 118.74,77.41 118.72,77.38 v1(118.49,77.38)
  BOTTOM w0.305: U20.C6 115.08,76.41 v1(115.27,76.22)
  vias: v1(120.7,78.76) v1(120.83,76.62) v1(121.44,76.37)
+1.8V_LDO_EC: length 18.4
  TOP w0.508: v1(138.21,53.55) v1(138.68,53.09) C859.1 U37.5
  IN1 w0.508: v1(131.05,41.9) 133.01,43.86 133.01,44.68 134.09,45.76 134.09,46.9 137.81,50.62 137.81,53.14 v1(138.21,53.55)
  BOTTOM w0.508: v1(131.05,41.9) 131.72,41.9 R1179.1
+1.8V_S5: length 399
  TOP w0.203: C258.2 114.17,59.02 U15.2
  TOP w0.254: PR204.1 127.76,50.94 126.68,49.86 126.68,45.77 125.8,44.89 118.84,44.89 115.82,41.88 114.66,41.88 113.5,40.72 113.5,39.85 112.51,38.87 111.45,38.87 v1(111.34,38.76)
  TOP w0.381: v1(38.74,63.54) 37.83,64.45 PR172.1
  TOP w0.508: v1(54.59,88.2) 53.58,88.2 51.7,86.32 51.69,86.32 ; v1(100.2,63.8) 100.25,63.8 100.28,63.77 101.51,63.77 102.8,65.07 106.35,65.07 108.59,62.83 108.59,62.19 108.84,61.94 108.84,57.74 109.98,56.6 v1(109.98,54.83) ; 51.69,86.32 45.37,86.32 44.64,87.06 43.24,87.06 42.35,87.95 v1(41.56,87.95) ; 51.69,86.32 51.69,85.84 51.39,85.54 51.39,82.57 52.15,81.8 52.15,78.09 51.06,77 v1(51.06,75.91) 51.06,75.16 R358.2 ; v1(84.91,88.64) 82.48,88.64 v1(82.32,88.8) 82.32,92.75 80.82,94.25 80.82,94.88 80.39,95.32 78.44,95.32 78.19,95.07 78.19,94.17 77.27,93.25 71.17,93.25 70.51,92.59 65.98,92.59 64.22,94.35 59.46,94.35 58.75,93.64 58.75,90.42 v1(59.2,89.97) ; R357.2 R358.2 ; R358.2 50.94,75.03 50.54,74.63 50.54,73.9 R115.2 ; v1(110.8,85.78) 110.8,84.15 109.02,82.38 109.02,79.72 108.21,78.91 v1(107.67,78.91) ; v1(80.28,88.76) 80.23,88.81 v1(78.59,88.81) ; v1(100.89,87.09) 101.23,87.43 104.66,87.43 104.97,87.75 104.97,88.28 105.28,88.59 v1(105.97,88.59) ; v1(140.9,25.07) 135.59,25.07 134.81,25.85 133.94,25.85 133.61,26.18 131.62,26.18 130.05,27.75 130.05,28.77 v1(130.48,29.2) ; v1(112.14,56.4) 112.14,56.68 112.6,57.14 112.6,58.31 113.44,59.15 C258.2 ; v1(94.79,68.65) 94.84,68.6 94.87,68.62 95.89,68.62 97.09,67.42 102.26,67.42 102.75,67.92 R224.1 R226.1 102.75,69.35 102.15,69.95 R225.1 ; v1(108.41,47.16) 108.46,47.16 109.65,45.97 111.45,45.97 112.06,45.35 v1(112.99,45.35) ; R1199.2 148.12,32.75 148.55,32.32 148.55,30.28 v1(147.99,29.72)
  IN1 w0.381: v1(38.74,63.54) 37.62,62.42 37.62,59.1 38.3,58.42 38.3,55.88 v1(38.33,55.84)
  IN1 w0.508: v1(59.2,89.97) 57.62,89.97 56.06,88.41 54.8,88.41 v1(54.59,88.2) ; v1(50.42,69.59) 50.42,68.37 v1(50.93,67.86) 50.93,67.25 50.34,66.67 49.43,66.67 49.02,66.26 v1(49.02,66.13) ; v1(131.93,38.4) 131.93,38.14 131.52,37.73 130.35,37.73 129.52,36.9 129.52,34.43 130.94,33.01 130.94,32.48 130.13,31.66 130.13,30.93 130.76,30.29 130.76,29.48 v1(130.48,29.2) 129.91,29.77 128.23,29.77 127.1,30.9 115.11,30.9 114.28,30.06 111.68,30.06 110.85,29.23 v1(110.85,29.1) ; v1(109.98,54.83) 111.56,56.4 v1(112.14,56.4) ; v1(117.63,99.28) 117.63,99.79 117.76,99.91 117.76,103.14 117.37,103.52 v1(117.02,103.52)
  IN2 w0.508: v1(110.85,29.1) 108.64,31.31 108.64,32.64 110.83,34.84 110.83,35.95 111.34,36.46 v1(111.34,38.76) 112.69,40.11 112.69,44.19 112.99,44.49 v1(112.99,45.35) 112.99,46.87 113.68,47.56 113.68,48.67 113.2,49.15 113.2,52.51 111.56,54.15 110.66,54.15 v1(109.98,54.83)
  BOTTOM w0.203: PU1.14 116.19,100.54 116.57,100.16 ; C319.2 109.52,54.27 110.24,54.27 110.47,54.5 110.47,55.06 110.62,55.21 U19.2
  BOTTOM w0.254: 116.57,100.16 116.66,100.07 117.12,100.07 117.48,100.42 PC14.1 ; U16.1 99.59,80.49 100.24,79.84 R428.1 100.92,79.84 101.36,79.4 102.83,79.4 103.03,79.6 103.03,80.81 102.88,80.96 Q36.5 Q36.2
  BOTTOM w0.381: v1(49.02,66.13) 49.02,65.93 50.67,64.28 50.67,59.4 46.97,55.69 38.48,55.69 v1(38.33,55.84)
  BOTTOM w0.508: v1(49.02,66.13) 49.02,66.27 R127.2 49.3,66.99 49.3,67.68 R97.2 ; C319.2 109.23,54.83 v1(109.98,54.83) ; v1(100.26,80.53) 100.26,80.53 R428.1 ; v1(93.86,85.28) 94.06,85.28 94.18,85.16 R81.1 ; v1(100.2,63.8) 100.13,63.72 98.88,63.72 98.05,64.55 97.92,64.55 97.67,64.8 R223.1 ; v1(78.59,88.81) 78.88,88.52 R307.1 78.65,88.14 78.2,87.69 R57.1 77.8,87.01 78.26,86.55 R305.1 ; v1(82.32,88.8) R1180.1 ; R1180.1 82.82,88.17 82.85,88.14 R1026.1 ; R1180.1 81.82,88.17 81.81,88.16 R1182.1 81,88.16 80.98,88.14 R33.1 v1(80.28,88.76) 80.28,89.61 80.01,89.88 ; R176.1 132.16,38.4 v1(131.93,38.4) ; v1(105.97,88.59) 105.42,88.59 R102.1 ; v1(91.11,95.47) R322.2 92.07,95.03 91.67,94.63 Q39.2 ; v1(147.99,29.72) 148.01,29.7 148.01,27.35 145.73,25.07 v1(140.9,25.07) ; R92.1 119.25,86.21 C59.2 119.22,86.18 U5.8 115.01,86.18 114.62,85.78 v1(110.8,85.78) 110.8,86.34 111.65,87.19 111.65,90.22 110.99,90.88 104.65,90.88 104.26,90.48 R77.1 103.15,90.26 102.62,89.73 Q32.2 102.24,88.3 101.24,87.3 100.96,87.3 100.89,87.23 v1(100.89,87.09) 100.89,86.51 100.3,85.92 R427.2 100.12,85.93 100.12,86.17 99.26,87.04 97.27,87.04 97.21,86.98 v1(95.92,86.98) 95.92,86.37 96.1,86.19 R232.2 97.21,85.29 R221.2 ; v1(110.85,29.1) 110.52,29.43 109.12,29.43 106.28,26.59 103.37,26.59 102.94,27.02 PR128.2 ; R329.1 90.16,82.26 90.6,82.7 91.13,82.7 91.52,82.31 v1(91.52,82.08) ; v1(54.59,88.2) 55.1,88.71 R46.2 ; R173.1 92.88,67.05 92.88,68.63 v1(92.79,68.72) ; R499.2 109.14,46.48 108.46,47.16 v1(108.41,47.16) 108.41,47.38 R498.2 ; v1(50.93,67.86) 50.93,68.23 51.43,68.73 R1009.2 ; R278.2 42.84,93.22 43.21,92.85 43.21,89.93 42.21,88.93 42.21,88.6 v1(41.56,87.95) ; v1(117.63,99.28) 117.63,99.63 117.79,99.8 PC14.1 ; v1(107.67,78.91) 107.5,79.08 R320.1
  vias: v1(85.52,97.93) v1(85.9,97.37) v1(86.28,97.93) v1(86.67,97.37) v1(87.05,97.93) v1(87.43,97.37) v1(87.81,97.93) v1(88.19,97.37) v1(88.6,88.84) v1(89.09,76.08) v1(89.26,88.76) v1(89.75,76.08) v1(90.41,76.08) v1(91.07,76.08) v1(92.25,69.18) v1(94.01,80.08) v1(94.13,68.65) v2(96.37,105.63) v2(97.33,108.7) v2(97.33,107.94) v2(97.33,107.18) v2(97.33,106.42) v2(116.31,104.82) v2(116.94,104.28)
+1.8VREF: length 4.5
  BOTTOM w0.203: 32.78,48.16 PU7.6
  BOTTOM w0.254: v1(33.66,45.53) 33.66,45.95 33.66,45.95 33.66,46.53 PC90.1 PR111.1 33.17,47.77 32.78,48.16
+1.15V: length 55.4
  TOP w1.016: v2(119.76,97.02) 121.79,94.99 121.79,93.83 123.26,92.36 123.26,82.69 126.64,79.31 126.64,77.97 126.51,77.84 126.51,76.79 126.81,76.49
  IN2 w1.016: 109.91,67.54 110.91,67.54 113.29,69.92 114.04,69.92 115.13,71.01 119.57,71.01 119.86,71.31 121.91,71.31 122.03,71.42 124.54,71.42 125.01,71.89 125.01,71.91 125.73,72.63 ; v2(119.76,97.02) 119.76,97.32 121.46,99.02 121.46,101.14 118.44,104.16 118.44,104.77 117.35,105.86 115.98,105.86 115.22,105.1 v2(115.22,104.89)
  vias: v1(102.54,65.98) v1(108.66,66.77) v1(108.81,66.11) v1(126.86,74.08) v1(127.51,74.15)
+1.24VS5: length 132
  TOP w0.762: 52.33,83.45 52.25,83.53 52.25,85.08 52.71,85.54 52.73,85.54 54,86.81 56.62,86.81 57.15,87.34 57.15,92.9 55.76,94.29 53.29,94.29 52.81,94.77 52.81,96.03 54.55,97.77 54.55,100.16 55.13,100.73 59.37,100.73 61.08,102.44 61.27,102.89 62.7,104.32 62.96,104.32 62.97,104.33 v1(63.88,104.33)
  IN1 w0.762: v1(63.88,104.33) 64.92,104.33 65.86,103.39 80.16,103.39 81.1,104.33 85.16,104.33 88.93,108.09 93.96,108.09 95.26,106.78 95.26,105.01 96.43,103.84 96.38,103.79 96.38,103.15 96.72,102.81 96.72,99.1 97.51,98.32 98.5,98.32 100.08,96.74 100.08,93.69 101.39,92.38 115.63,92.38 116.29,91.72 118.35,91.72 v1(118.73,92.11)
  IN2 w0.762: v2(112.68,106.4) 113.17,106.89 115.87,106.89 116.58,107.6 118.12,107.6 118.87,106.85 118.87,106.26 119.25,105.88 120.63,105.88 120.84,105.67 120.84,103.22 122.49,101.56 122.49,96.98 118.73,93.22 v1(118.73,92.11)
  BOTTOM w0.381: PC121.1 113.36,105.71 v2(112.68,106.4)
  vias: v1(53.75,75.58)
+1.35VSUS: length 92.2
  TOP w0.254: U27.H2 96.6,46.59 96.99,46.99 v3(97.01,46.99) ; U24.G7 47.77,47.35 v3(48.16,46.95) ; v3(59.88,52.39) 60.52,52.39 U25.A1 ; U25.A8 66.35,52.61 v3(66.43,52.69) ; U27.G7 100.6,47.33 v3(101.02,46.91) ; U26.A8 83.62,52.17 83.62,52.75 v3(83.51,52.85) ; v3(66.75,41.37) U25.R9 ; U24.H2 43.77,46.6 v3(44.15,46.98) ; v3(96.21,45.35) U27.K2
  TOP w0.305: v3(65.94,46.97) 65.54,47.37 ; U25.C9 v3(66.76,50.18)
  TOP w0.508: 51.06,60.8 49.61,60.8 C869.2 ; v1(121.41,75.71) 121.28,75.58 121.28,73.63 122.07,72.84 122.07,71.31 120.53,69.77 v1(120.53,69.54) ; 106.3,53.94 106.68,54.32 C870.2 109.73,53.94 110.64,53.94 110.95,54.24 v1(110.95,54.8)
  IN1 w0.127: 78.79,46.55 79.57,46.55 v3(79.98,46.97) 79.58,47.37 78.86,47.37 v3(78.42,46.93) 78.79,46.55
  IN1 w0.305: v3(64.75,47.31) 65.6,47.31 v3(65.95,46.97)
  IN2 w0.152: v3(101.02,46.91) 101.46,47.35 102.2,47.35 102.62,46.93 v3(102.62,46.92)
  IN2 w0.508: v1(110.95,54.8) 110.37,55.38 110.37,56.53 111.22,57.38 111.22,64.11 116.57,69.46 120.46,69.46 v1(120.53,69.54)
  BOTTOM w0.203: 34.03,50.5 PU7.2
  BOTTOM w0.254: v1(57.96,60.19) U7.BE53 ; v1(59.7,61.7) 59.76,61.64 U7.BE51 ; v1(82.46,60.87) 82.51,60.92 U7.BE3 ; U7.BE1 v1(84.84,60.19) 85.04,59.99 85.04,59.48 ; U7.AV44 v1(62.71,63.68) U7.AY44 ; v1(65.57,64.24) U7.AV38 ; v3(61.63,52.79) 61.55,52.71 U32.A8 ; 75.58,66.59 U7.AN19 75.29,66.08 v1(75.57,65.79) U7.AN18 75.58,66.56 75.58,66.59 ; 75.58,66.59 U7.AM18 ; v1(66.56,64.23) 66.68,64.23 U7.AU36 ; v1(77.23,64.24) U7.AV16 ; U7.AV10 v1(80.09,63.68) U7.AY10 ; 67.34,65.91 v1(67.23,65.79) 66.85,66.17 U7.AN36 U7.AM36 67.5,66.3 U7.AN35 67.34,65.91
  BOTTOM w0.305: U27.R9 102.2,40.95 v3(102.62,40.53) ; 77.48,52.59 77.51,52.62 78.33,52.62 78.37,52.59 ; U33.A1 102.2,52.35 v3(101.91,52.64) ; v1(76.24,64.95) 75.88,64.59 U7.AU18 ; U33.H2 101.36,46.57 v3(101.02,46.91)
  BOTTOM w0.33: v3(60.23,48.56) 60.34,48.56 U32.E9
  BOTTOM w0.381: U33.B2 101.4,51.38 v3(101.02,51.76) ; v3(78.42,45.35) 78.8,44.97 U26.K2
  BOTTOM w0.508: R465.2 106.78,78.17 108.41,78.17 109.12,78.88 109.12,79.64 110.75,81.27 118.77,81.27 121.82,78.22 121.82,76.88 122.05,76.64 122.05,76.04 121.72,75.71 v1(121.41,75.71)
  vias: v1(50.82,40.96) v1(53.43,57.16) v1(54.29,57.16) v1(60.3,59.82) v1(67.88,37.4) v1(69.25,43.5) v1(70.49,46.07) v1(70.79,43.4) v1(72.44,43.45) v1(72.77,44.8) v1(74.36,43.88) v1(75.15,42.61) v1(82.5,59.82) v1(82.7,58.1) v1(83.43,58.11) v1(85.79,41.37) v1(100.59,35.6) v1(101.25,35.8) v2(38.1,38.06) v2(38.1,37.3) v2(38.48,36.54) v2(38.48,35.78) v2(38.86,38.06) v2(38.86,37.3) v2(39.24,36.54) v2(39.24,35.78) v2(39.24,35.02) v2(39.63,37.3) v3(39.25,39.72) v3(41.34,46.55) v3(41.79,34.64) v3(41.94,49.27) v3(42.51,48.52) v3(42.55,42.18) v3(42.57,41.37) v3(43.06,37.3) v3(43.37,51.77) v3(43.39,45.35) v3(43.44,35.27) v3(44.33,34.64) v3(48.19,51.76) v3(48.97,49.37) v3(48.97,45.38) v3(49.08,52.64) v3(49.77,50.97) v3(49.77,49.37) v3(49.77,47.77) v3(49.79,46.96) v3(60.16,50.54) v3(61.15,46.93) v3(61.15,45.32) v3(61.15,40.55) v3(62.97,47.5) v3(66.76,45.37) v3(67.55,48.57) v3(67.55,42.17) v3(67.57,49.29) v3(67.77,50.18) v3(77,42.51) v3(77.12,52.02) v3(77.43,50.53) v3(77.5,48.56) v3(78.41,50.17) v3(78.42,40.55) v3(83.22,46.97) v3(83.25,45.35) v3(84.03,50.18) v3(84.84,52.57) v3(84.8,48.55) v3(85.05,50.18) v3(94.45,42.97) v3(95.26,46.65) v3(95.4,49.37) v3(96.2,51.77) v3(96.19,40.6) v3(101.8,49.37) v3(101.81,45.38) v3(102.6,50.97) v3(102.6,49.37) v3(102.61,47.82) v3(102.82,41.96) v4(95.76,57.67)
+3V: length 395.5
  TOP w0.203: U4.36 4.97,15.6 4.83,15.45 C58.1 ; U4.1 12.56,15.6 12.65,15.69 C53.1
  TOP w0.381: v1(133.67,44.4) 134.11,43.95 R215.2 ; R216.2 135.25,43.66 135.25,44.25 v1(135.52,44.52) ; R1173.2 146.59,39.21 v1(147.35,38.45) 147.35,36.93 146.77,36.35 R1172.2
  TOP w0.457: C58.1 5.22,14.45 v1(5.43,14.67) ; R41.1 12.33,23.02 12.32,23.03 v1(12.32,23.08)
  TOP w0.508: v1(14.03,14.71) 14.04,14.71 14.56,15.24 C56.1 14.35,15.69 C53.1 ; 115.81,45.25 R1194.2 ; 115.81,45.25 116.45,45.25 116.99,44.72 v1(117.86,44.72) ; 115.81,45.25 115.85,45.29 115.85,46.23 R1189.1 ; PR138.1 PR238.1 101.31,89.89 102.14,90.72 102.14,91.78 101.21,92.71 R429.2 100.97,93.31 99.59,94.69 99.59,99.13 98.68,100.04 98.02,100.04 v1(96.88,101.18) v1(95.1,101.18) ; Q43.2 88.75,80.5 R504.2 ; Q43.2 87.87,81.65 R1126.1 ; Q43.2 88.75,82.36 89.15,82.76 89.94,82.76 90.45,83.28 v1(90.46,83.43) ; U38.8 109.35,49.15 109.99,49.8 C861.1 110.49,50.13 v1(111.96,51.6) 111.96,51.61 R434.1 ; R105.1 R252.2 28.7,20.54 29.11,20.95 29.11,22.37 29.39,22.65 v1(30.94,22.65) 30.94,24.14 30.2,24.87 30.2,26.25 29.69,26.77 29.69,28.19 30.05,28.55 30.56,28.55 30.68,28.43 32.3,28.43 33.15,29.28 33.15,29.86 v1(33.35,30.06) 33.35,31.26 32.56,32.05 32.56,45.62 35.45,48.51 35.45,52.46 PR104.2 34.05,53.17 33.02,54.19 33.02,56.61 33.66,57.24 33.66,58.13 32.97,58.82 28.83,58.82 v1(28.32,58.31) ; v1(21.26,28.18) 21.09,28.02 21.09,27.3 21.36,27.03 21.99,27.03 22.47,27.52 R1205.1 C874.1 23.51,27.53 25.79,27.53 Q77.1 ; R129.2 67.1,102.21 R1206.1 65.79,103.47 65.28,103.98 64.64,103.98 64.24,103.57 63.64,103.57 R781.1 62.66,101.73 63.45,101.73 R114.1 63.93,101.25 63.93,97.81 65.13,96.61 67.82,96.61 68.15,96.28 69.98,96.28 70.22,96.04 R108.1 70.39,95.27 71.58,95.27 v1(72.25,94.59) ; R459.1 122.97,38.67 v1(122.84,38.8) ; v1(125.17,58.92) 125.51,58.92 PR58.2 ; R197.2 111.22,39.72 R199.2 110.13,39.5 109.61,38.98 107.18,38.98 v1(107.05,39.11) ; v1(112.2,54.46) 112.19,54.46 v1(111.72,54.92) 111.39,55.25 111.39,56.06 109.48,57.98 109.48,62.18 109.2,62.45 109.2,63.09 108.39,63.9 108.39,64.66 109.48,65.75 109.48,67.5 108.43,68.55 107.75,68.55 107.42,68.22 107.42,68.2 107.41,68.19 107.41,67.37 106.71,66.67 103.83,66.67 v1(103.55,66.94) ; v1(115.42,50.28) 114.76,50.94 114.76,52.19 R433.1 R432.1 ; v1(135.52,44.52) 135.52,44.65 135.84,44.97 135.84,50.1 R481.2 ; v1(32.67,70.42) 34.27,70.42 35.15,69.54 36.17,69.54 36.79,68.92 PR52.2 ; Q19.2 20.63,75.11 R289.1 21.84,74.74 v1(21.84,74.53)
  TOP w2.032: 132.67,61.36 134.51,61.36 136.34,59.52 142.1,59.52 144.45,57.17 144.45,56.05
  IN1 w0.508: v1(28.32,58.31) 28.77,58.75 28.77,60.39 29.27,60.89 29.9,60.89 30.59,61.58 30.59,65.09 28.68,67 v1(28.68,67.53) ; v1(14.03,14.71) 14.02,14.71 12.22,16.51 ; v1(32.67,70.42) 33.33,71.08 33.33,76.21 35.24,78.12 36.22,78.12 40.39,82.29 40.39,85.05 41.1,85.77 v1(41.63,85.77) ; v1(21.26,28.18) 20.83,27.76 20.83,27.75 20.45,27.37 20.42,27.37 20.32,27.27 19.53,27.27 19.1,26.84 19.1,24.81 19.99,23.92 v1(21.36,23.92) 22.12,23.92 22.58,23.46 26.8,23.46 27.41,22.85 30.71,22.85 v1(30.94,22.65) ; v1(12.32,23.08) 12.19,22.95 12.19,16.54 12.22,16.51 ; 12.22,16.51 6.38,16.51 5.92,16.05 5.92,15.15 5.44,14.67 v1(5.43,14.67)
  IN2 w0.508: v1(122.84,38.8) 121.52,38.8 120.52,37.81 119.25,37.81 118.87,38.19 118.87,40.1 117.86,41.11 v1(117.86,44.72) 117.86,46.04 117.51,46.38 117.51,48.06 118.49,49.04 118.49,53.66 117.79,54.36 116.54,54.36 v1(116.38,54.19) ; v1(21.36,23.92) 16.16,23.92 15.11,24.96 13.74,24.96 12.32,23.54 v1(12.32,23.08) ; v1(145.87,55.33) 147.31,53.89 147.31,50.31 148.14,49.48 v1(148.14,44.58) 146.92,43.35 144.92,43.35 144.76,43.51 142.4,43.51 141.65,42.76 139.21,42.76 138.16,43.8 135.85,43.8 135.52,44.14 v1(135.52,44.52) 135.47,44.57 133.84,44.57 v1(133.67,44.4)
  BOTTOM w0.508: R300.2 41.68,92.29 v1(41.68,92.65) ; v1(41.63,85.77) 40.88,86.52 R282.2 41.56,86.96 42.83,88.23 42.83,88.61 43.99,89.78 44.48,89.78 ; R135.1 127.38,70.36 v1(126.85,70.89) ; 44.45,93.21 41.68,95.98 R279.2 ; v1(148.14,44.58) 148.14,39.23 v1(147.35,38.45) ; R1144.1 32.65,31.71 33.35,31 v1(33.35,30.06) 38.16,30.06 39.13,29.09 R301.2 R306.1 ; v1(86.23,93.74) 86.23,95.82 87.15,96.74 93.02,96.74 93.93,97.65 93.93,100.68 94.44,101.18 v1(95.1,101.18) ; v1(103.55,66.94) 103.55,66.23 102.89,65.57 U8.1 101.15,65.57 100.79,65.93 C101.1 100.47,65.93 R182.2 ; v1(32.67,70.42) 32.26,70.42 31.97,70.71 R1116.2 31.5,70.96 30.71,71.75 29.97,71.75 29.21,70.98 28.5,70.98 28.27,71.21 25.27,71.21 23.62,72.86 23.62,73.88 22.97,74.53 v1(21.84,74.53) ; v1(90.46,83.43) 90.31,83.28 R1031.1 ; v1(90.43,88.07) R416.2
  vias: v1(120.76,72.49) v1(121.41,72.51) v1(131.2,62.66) v1(131.2,62) v1(131.2,61.34) v1(131.2,60.68) v1(145.21,54.24) v1(148.08,105.7) v1(148.26,105.07) v1(148.27,104.42) v1(148.46,106.23) v2(44.04,92.53) v2(43.96,91.62) v2(44.72,91.66) v2(44.79,92.49) v2(126.38,100.38) v2(126.38,99.63) v2(126.38,98.89) v2(126.38,98.14)
+3V3_SER: length 201.2
  TOP w0.508: R486.1 121.25,26.29 120.3,27.24 120.3,29.45 120.37,29.53 v1(120.37,29.6) ; Q54.3 63.2,98.64 63.2,100.85 v1(63.12,100.93) 63.1,100.93 63.07,100.97 R781.2 61.07,100.97 60.1,99.99 C840.1 C841.1 57.69,98.22 v1(57.66,98.19) ; v1(130.91,28.41) 132.53,26.79 134.86,26.79 138.61,30.55 v1(140.98,30.55)
  IN1 w0.508: v1(140.98,30.55) 142.46,32.03 142.46,34.48 142.79,34.8 142.79,37.77 151.12,46.1 151.12,55.5 150.47,56.14 150.47,63.96 145.47,68.96 145.47,72 143.01,74.46 143.01,78.07 138.68,82.4 131.66,82.4 131.32,82.06 128.98,82.06 127.71,83.32 123.64,83.32 121.49,85.47 120.8,85.47 118.34,87.94 105.7,87.94 105.05,88.59 103.54,88.59 102.35,89.78 100.31,89.78 97.6,92.48 93.94,92.48 93.37,93.05 93.37,99.12 93.43,99.19 93.43,105.92 93.08,106.28 89.78,106.28 86.72,103.22 86.67,103.22 84.56,101.11 v1(82.36,101.11) ; v1(120.37,29.6) 120.99,30.22 126.49,30.22 127.59,29.12 129.41,29.12 130.12,28.41 v1(130.91,28.41)
  BOTTOM w0.508: v1(63.12,100.93) 63.12,102.58 64.19,103.65 68.43,103.65 69.24,104.45 81.39,104.45 82.62,103.22 82.62,101.37 v1(82.36,101.11)
+3V_EC: length 5.9
  TOP w0.203: 125.1,34.26 125.46,33.9 U9.11
  TOP w0.508: R459.2 R1030.2 124.17,35.95 124.34,35.78 v1(124.31,35.78) 124.34,35.74 C287.1 125.1,34.26
+3V_EMMC: length 2.5
  BOTTOM w0.305: v1(118.03,73.93) 118.03,74.03 117.75,74.32 U20.J10 ; v1(116.28,76.01) 116.23,76.01 115.84,76.41 U20.E6 ; v1(117.78,75.17) 118.05,74.91 U20.K9 ; v1(116.03,77.43) 116.25,77.21 U20.F5
+3V_LDO: length 72.1
  TOP w0.508: U37.1 139.63,56.19 139.84,55.98 C860.1 v1(142.03,55.98) v1(142.03,50.89) 142.03,47.37 144.1,45.3 144.41,45.3 145.02,44.7 R1177.1 ; v1(134.73,75.16) 133.17,75.16 132.73,75.6 132.73,77.53 132.37,77.89 131.89,77.89 130.7,79.08 130.7,82.12 131.73,83.15 131.73,84.55 135.92,88.74 135.92,92.75 136.7,93.53 136.7,93.99 v1(136.78,94.07)
  IN2 w0.508: v1(142.03,55.98) 141.48,55.98 141.31,56.15 141.31,65.07 142.33,66.09 142.33,70.62 141.71,71.24 141.71,73.34 140.24,74.81 138.31,74.81 137.96,75.16 v1(134.73,75.16)
  BOTTOM w0.203: PR157.2 136.73,94.69 PU3.6
  BOTTOM w0.508: PR157.2 137.29,94.93 137.29,94.55 137.58,94.26 PC33.2 136.96,93.89 v1(136.78,94.07)
+3V_MINI1_VDD: length 22.7
  TOP w0.254: Q25.2 144.82,79.46 145.12,79.77 146.31,79.77 147.16,80.62 R331.2 148.08,81.33 147.73,81.69 147.73,82.7 R598.1 148.5,82.64 v1(148.5,81.91)
  IN1 w0.254: 153.65,92.19 150.45,92.19 148.84,90.59 148.84,82.25 v1(148.5,81.91)
  vias: v1(149.1,105.29) v1(149.76,105.29) v1(150.17,104.67) v1(150.42,105.29) v1(151.08,105.29) v1(156.92,107) v2(153.49,93.18) v2(154.01,93.79)
+3V_RTC: length 176.5
  TOP w0.254: D17.3 C294.1 144.28,100.07 R38.1 R58.1 145.28,100.08 v1(145.59,100.4) ; v1(152.78,69.33) 152.65,69.2 149.69,69.2 147.06,71.83 145.05,71.83 140.37,67.15 134.61,67.15 v1(134.31,67.44) ; v1(83.9,87.75) 83.37,87.75 R318.1 ; R998.1 151.64,28.69 150.34,29.99 v1(150.12,29.99) ; R259.1 150.69,42.77 150.96,42.5 R1037.1 153.45,42.5 154,41.95 v1(154.16,41.95)
  IN1 w0.254: v1(154.16,41.95) 154,41.95 153.63,42.32 153.63,56.52 152.97,57.18 152.97,68.81 152.78,69 v1(152.78,69.33) 152.78,70.42 147.07,76.13 147.07,76.84 146.43,77.49 146.43,79.36 146.21,79.57 146.21,82.98 146.67,83.43 146.67,95.02 147.58,95.93 147.58,98.34 145.59,100.32 v1(145.59,100.4) ; v1(83.9,87.75) 84,87.65 84,87.49 86.06,85.43 87.63,85.43 89.13,83.93 89.13,81.26 90.13,80.26 93.47,80.26 94.15,79.58 95.54,79.58 99.74,75.38 102.83,75.38 103.64,76.18 107.71,76.18 108.65,75.24 108.65,74 111.97,70.68 119.1,70.68 119.73,71.32 122.31,71.32 123.23,70.41 125.63,70.41 127.22,71.99 128.68,71.99 129.5,71.18 130.22,71.18 130.57,70.83 130.57,69.8 132.6,67.78 133.98,67.78 v1(134.31,67.44)
  BOTTOM w0.254: v1(150.12,29.99) 149.48,30.62 149.48,34.78 150.58,35.87 150.58,37.77 154.16,41.35 v1(154.16,41.95)
+3V_RTC_0: length 7.2
  TOP w0.508: Q31.1 141.73,102.26 141.34,102.65 R479.2 139.68,103.22 v1(138.74,102.27) CN7.1
+3V_RTC_R: length 1.3
  TOP w0.203: v1(136.85,38.4) 137.1,38.65 U9.106
  vias: v1(138.96,37.94)
+3V_S5: length 366.8
  TOP w0.381: v1(134.92,49.46) 135.22,49.15 R1023.2 ; R1024.2 134.13,46.11 v1(134.13,47.86)
  TOP w0.508: R782.2 v1(61.19,96.94) 61.39,96.74 62.31,96.74 Q54.1 63.94,95.11 64.33,95.11 66.23,93.21 70.25,93.21 71.01,93.96 77.11,93.96 77.57,94.43 77.57,95.57 78.26,96.26 80.65,96.26 82.58,94.33 82.58,93.79 v1(83.36,93.01) 83.36,92.6 82.94,92.17 82.94,90.01 83.57,89.37 85.22,89.37 85.65,88.94 85.65,88.12 R309.1 ; v1(30.33,71.11) 31.19,70.25 31.19,66.69 33.15,64.73 R1113.1 33.39,63.73 35.54,61.57 35.54,61.1 35.03,60.59 35.03,56.19 36.07,55.16 36.07,48.25 33.18,45.36 33.18,32.7 v1(34.57,31.31) ; v1(121.06,82.74) 121.06,85.93 119.33,87.66 119.33,91.32 119.71,91.7 119.71,93.89 115.83,97.78 114.28,97.78 113.72,98.34 v1(113.72,98.52) 113.72,98.76 PC114.1 ; R1030.1 122.06,36.67 121.46,37.26 121.46,38.93 121.04,39.35 121.04,41.04 121.11,41.12 v1(121.11,41.82) 120.46,41.82 120.18,42.1 v1(120.18,42.93) 120.69,43.44 123.59,43.44 125.4,41.63 v1(127.6,41.63) ; v1(101.88,80.56) 101.88,80.86 102.08,81.06 102.08,86.65 v1(101.91,86.82)
  IN1 w0.508: v1(101.91,86.82) 102.2,86.53 v1(103,86.53) 103,86.42 103.54,85.88 104.18,85.88 104.42,86.12 v1(104.42,86.33) 104.85,85.9 109.76,85.9 110.61,85.05 114.3,85.05 116.39,82.96 120.84,82.96 v1(121.06,82.74) 122.24,81.56 126.98,81.56 128.27,80.27 132.03,80.27 132.39,80.63 136.15,80.63 138.93,77.86 138.93,77.04 140.63,75.33 140.63,73.55 v1(142.36,71.82) ; v1(101.88,80.56) 101.88,80.52 100.92,79.57 99.77,79.57 99.31,80.03 99.31,80.91 98.37,81.85 97.39,81.85 96.83,82.42 96.83,83.18 96.25,83.75 94.96,83.75 v1(94.87,83.84) 94.5,84.21 94.5,85.55 93.73,86.32 93.09,86.32 89.99,89.42 89.08,89.42 88.25,90.25 88.25,90.81 86.44,92.62 83.62,92.62 83.36,92.88 v1(83.36,93.01) ; v1(30.33,71.11) 30.24,71.2 30.24,72.22 30.02,72.44 27.47,74.99 27.47,80.19 28.91,81.63 28.91,85.94 31.94,88.98 33.41,88.98 39.07,94.64 47.05,94.64 48.1,95.68 53.83,95.68 54.48,96.33 55.02,96.33 55.66,95.69 59.93,95.69 v1(61.19,96.94) ; v1(121.11,41.82) 113.47,41.82 111.18,44.11 v1(111.18,45.35) ; v1(137.15,52.71) 137.15,50.92 135.71,49.47 134.93,49.47 v1(134.92,49.46) 134.92,48.65 v1(134.13,47.86) 133.44,47.17 133.44,46.02 132.36,44.95 132.36,44.22 131.68,43.54 129.51,43.54 v1(127.6,41.63)
  IN2 w0.508: v1(83.36,93.01) 76.02,93.01 75.54,92.53 75.54,91.63 75.85,91.32 v1(75.85,90.38)
  BOTTOM w0.203: PU1.18 113.77,98.57 v1(113.72,98.52)
  BOTTOM w0.254: U16.6 99.59,84.57 100.08,85.05 100.69,85.05 101.12,85.49 101.12,85.97 101.52,86.38 101.52,86.43 v1(101.91,86.82)
  BOTTOM w0.305: U18.5 111.51,46.83 111.76,46.57 111.76,45.93 v1(111.18,45.35)
  BOTTOM w0.381: R491.2 101.77,80.41 101.88,80.52 v1(101.88,80.56) ; v1(104.42,86.33) 104.42,86.24 105.34,85.33 R470.1
  BOTTOM w0.508: v1(137.15,52.71) 138.39,52.71 138.83,53.15 138.83,55.28 141.23,57.67 141.23,66.45 142.36,67.59 v1(142.36,71.82) 142.36,72.21 R149.1 ; R328.1 89.5,81.16 92.78,81.16 93.4,81.78 93.4,82.48 93.51,82.6 R231.1 ; v1(75.85,90.38) R430.1 R49.2 ; R507.1 52.07,27.57 53.29,28.79 53.29,29.53 52.73,30.09 39,30.09 37.78,31.31 v1(34.57,31.31) ; R463.1 111.4,44.67 111.4,45.13 v1(111.18,45.35) ; v1(103,86.53) 103,86.07 102.37,85.44 R441.2 ; R299.1 84.08,92.44 83.51,93.01 v1(83.36,93.01)
+3V_SRC: length 48.8
  TOP w0.508: v1(145.8,96.1) 145.09,96.1 PR146.1
  IN1 w0.508: v1(145.8,96.1) 144.78,96.1 142.09,93.41 139.2,93.41 137.26,91.48 137.26,88.42 134.83,85.99 126.04,85.99 v1(125.39,86.64)
  BOTTOM w0.203: 136.2,93.72 136.2,94.08 135.99,94.29 PU3.7
  BOTTOM w0.254: PC30.1 124.22,85.74 127.38,85.74 127.61,85.97 130.7,85.97 130.82,85.84 133.1,85.84 135.15,87.9 136.65,87.9 137.29,88.53 137.29,90.47 136.87,90.88 PC35.1 136.87,93.04 136.2,93.72
+3V_SSD: length 1.3
  TOP w1.016: CN9.8 154.95,55.89
  vias: v1(153.93,56.35)
+3V_USB: length 32.2
  TOP w0.381: C867.2 27.04,59.73 v1(27.35,60.04)
  TOP w0.508: v1(28.32,69.56) 28.45,69.69 v1(30.51,69.69)
  IN1 w0.508: v1(32.25,63.57) 32.25,65.78 30.51,67.53 v1(30.51,69.69)
  BOTTOM w0.254: v1(29.57,60.09) 29.58,60.1 U35.9 ; v1(32.25,63.57) 32.28,63.54 32.28,63.52 32.31,63.49 32.31,63.46 31.94,63.09 U35.5 ; C803.2 30.6,67.24 30.08,66.72 U35.28 ; U35.14 27.08,60.31 v1(27.35,60.04)
  BOTTOM w0.508: R1123.2 R1118.2 R1117.2 R1122.2 C805.2 R1119.2 23.49,69.55 24.11,70.17 27.18,70.17 27.79,69.56 v1(28.32,69.56) R1115.2 R1114.2 ; R1116.1 30.75,69.93 v1(30.51,69.69) 30.6,69.6 C798.2 C803.2
  vias: v1(32.08,62.68)
+3V_USB_D: length 3.1
  BOTTOM w0.305: U35.21 25.37,65.09 25.2,65.27 25.2,66.51 v1(25.07,66.64) R1122.1
+3VPCU: length 579.9
  TOP w0.254: R990.2 R991.2 139.61,107.7 139.61,104.19 140.08,103.72 141.25,103.72 141.78,104.25 MR3.3 142.51,104.25 143.16,104.89 C576.2 143.65,105.13 143.94,105.43 144.86,105.43 145.71,104.57 145.71,102.7 D17.2
  TOP w0.457: R107.2 13.46,27.81 14.05,27.22 v1(14.05,26.37) ; PR125.2 95.41,28.1 94.71,28.8 PC164.1 v1(94.71,29.88) PR228.2 94.71,30.7 96.88,32.87 98.24,32.87 98.67,32.44 PR221.2
  TOP w0.508: 56.61,24.67 53.1,24.67 48.77,20.34 48.77,19.14 46.86,17.24 39.63,17.24 38.99,17.87 38.99,18.89 37.21,20.67 37.21,26.63 v1(36.91,26.94) 37.62,27.65 39.68,27.65 v1(40.38,26.96) ; 56.61,24.67 56.61,28.13 57.09,28.62 93.38,28.62 94.63,27.36 PR125.2 ; 56.61,24.67 62.83,18.45 PR223.2 ; v1(120.91,97.15) 120.1,97.96 119.4,97.96 119.02,98.34 119.02,98.85 119.28,99.11 119.28,100.45 118.82,100.9 PR6.1 ; v1(154.16,42.6) 152.76,43.99 148.81,43.99 148.08,43.27 R257.1 146.79,42.77 R1178.1 ; v1(64.82,103.01) 64.75,102.94 64.26,102.94 63.87,102.55 R1207.1 ; PC116.1 114.43,98.62 v1(114.38,98.57) ; R17.2 153.57,103.24 152.93,102.61 Q27.1 152.67,101.73 151.65,100.71 R281.1 151.41,100.32 150.61,99.52 C75.1 R376.1 149.23,98.42 v1(148.92,98.11) ; v1(81.69,103.04) 80.82,102.17 80.82,100.75 81.26,100.32 81.26,96.64 82.09,95.8 83.03,95.8 84.18,94.66 84.18,92.52 83.66,92 83.66,90.55 84.21,90 85.62,90 86.26,89.37 v1(86.26,89.09) 86.36,88.99 R303.1 86.65,87.31 87.2,86.76 87.2,85.62 86.36,84.78 v1(86.36,84.67) ; v1(14.05,26.37) 12.69,26.37 11.84,25.52 11.84,24.73 12.13,24.44 R1014.1 ; v1(104.99,24.96) 104.72,25.23 PR123.2 ; v1(114.46,90.76) 114.46,90.03 115.35,89.14 115.35,86.5 114.79,85.94 PQ32.3 113.93,83.01 114.49,82.45 117.32,82.45 118.19,81.58 119.14,81.58 122.02,78.7 122.02,77 122.28,76.74 122.28,75.52 121.9,75.15 121.9,73.88 122.69,73.09 122.69,70.83 v1(122.38,70.52) ; R248.2 v1(147.93,30.73) ; v1(144.28,102.06) D17.2 ; v1(127.1,44.52) 126.05,43.47 R435.2
  IN1 w0.508: v1(141.48,24.29) 138,24.29 136.76,23.05 128.52,23.05 127.37,24.2 124.51,24.2 124.23,23.92 122.76,23.92 122.05,23.21 v1(121.9,23.21) 120.65,23.21 119.97,23.89 118.62,23.89 117.52,22.79 115.87,22.79 115.17,22.1 107.28,22.1 104.99,24.39 v1(104.99,24.96) 104.55,25.4 104.32,25.63 104.32,27.02 102.32,29.02 95.16,29.02 94.71,29.48 v1(94.71,29.88) ; v1(122.38,70.52) 122.09,70.8 119.95,70.8 119.31,70.16 111.75,70.16 108.13,73.78 108.13,75.02 107.49,75.66 103.86,75.66 103.05,74.86 99.52,74.86 95.35,79.04 93.9,79.04 93.25,79.69 89.96,79.69 89.03,80.62 88.61,81.05 88.61,83.7 88.13,84.17 86.86,84.17 v1(86.36,84.67) ; v1(154.16,42.6) 154.16,56.74 153.49,57.4 153.49,69.03 154.01,69.55 154.01,69.93 147.59,76.35 147.59,77.06 146.95,77.71 146.95,79.58 146.73,79.79 146.73,82.76 147.19,83.21 147.19,94.8 148.1,95.71 148.1,97.29 v1(148.92,98.11) 148.92,100.24 148.06,101.11 146.93,101.11 145.97,102.06 v1(144.28,102.06) 143.38,101.17 143.38,98.06 140.87,95.55 138,95.55 v1(136.52,97.02) 135.74,96.23 134.46,96.23 134.11,96.57 130.9,96.57 130.3,95.98 130.3,94.96 129.67,94.33 122.86,94.33 v1(122.81,94.38) ; v1(114.38,98.57) 115.11,97.83 120.22,97.83 v1(120.91,97.15) ; v1(14.05,26.37) 16.94,29.25 18.03,29.25 19.3,30.52 21.94,30.52 22.43,30.03 29.12,30.03 30.25,28.9 32.36,28.9 32.91,28.35 32.91,26.95 33.12,26.74 36.7,26.74 v1(36.91,26.94)
  IN2 w0.508: v1(154.16,42.6) 154.05,42.71 145.34,42.71 143.64,41.01 141.16,41.01 140.37,40.22 135.29,40.22 132.96,42.55 129.48,42.55 128.69,43.34 127.72,43.34 127.1,43.96 v1(127.1,44.52)
  BOTTOM w0.203: v1(114.38,98.57) 114.17,98.78 PU1.17
  BOTTOM w0.305: v1(121.49,32.05) 122.18,32.73 126.37,32.73 128.53,34.89 RP1.10 131.9,34.89 132.08,34.71 132.08,32.55 132.28,32.35 RP1.5
  BOTTOM w0.508: v1(154.16,42.6) 153.84,42.6 148.9,37.66 148.9,35.4 148.63,35.13 148.63,31.39 147.97,30.73 v1(147.93,30.73) 148.63,30.03 148.63,27.1 145.82,24.29 v1(141.48,24.29) ; v1(81.69,103.04) 81.69,103.27 81.12,103.84 72.37,103.84 69.47,100.94 69.47,99.33 68.84,98.69 67.11,98.69 65.51,100.29 65.51,102.33 v1(64.82,103.01) ; v1(94.71,29.88) 94.71,29.55 94.96,29.3 PR92.2 95.12,29.04 95.18,28.95 PR91.2 ; JP1.2 120.21,92.54 118.95,91.28 116.71,91.28 116.46,91.53 114.9,91.53 114.46,91.09 v1(114.46,90.76) ; v1(86.26,89.09) 85.95,89.4 R79.2 ; R293.1 R310.1 v1(40.38,26.96) ; PR156.1 v1(136.52,97.02) ; v1(121.9,23.21) 122.06,23.21 123.52,24.67 123.52,28.34 122.38,29.48 v1(122.38,29.57) ; v1(14.05,26.37) 13.39,25.7 13.39,21.25 11.16,19.03 11.16,12.65 10.4,11.89 9.79,11.89 8.94,11.04 8.94,10.74 8.94,10.73 8.94,10.22 8.94,10.21 8.94,9.43 8.62,9.11 8.62,8.8 7.79,7.96 7.79,6.43 v1(5.61,4.26)
  vias: v1(122.05,30.98)
+3VPCU_EC: length 66.3
  TOP w0.203: 125.5,28.48 125.68,28.3 125.68,28.01 125.79,27.9 U9.26 ; v1(140.98,36.34) 141.02,36.3 U9.92 ; v1(131.1,38.4) U9.121 ; U9.50 135.1,22.55
  TOP w0.381: 135.1,22.55 134.73,22.18 C124.1
  TOP w0.508: 125.5,28.48 125.37,28.61 124.52,28.61 C297.1 124.46,28.62 124.01,29.07 v1(123.96,29.07) ; v1(134.47,21.31) 134.47,21.51 134.73,21.77 C124.1
  BOTTOM w0.508: 140.23,29.89 140.24,29.9 141.34,29.9 141.83,29.4 141.83,28.63 L11.1 ; 140.23,29.89 140.23,32.07 139.5,32.81 139.5,34.41 140.11,35.02 140.11,36.45 140.49,36.83 ; 140.23,29.89 140.23,29.25 139.57,28.59 139.57,28.03 138.09,26.55 135.26,26.55 134.93,26.22 134.93,25.77 135.26,25.44 135.26,22.83 134.47,22.04 v1(134.47,21.31) 134.47,21.05 134.11,20.69 124.83,20.69 124.46,21.06 124.46,28.57 v1(123.96,29.07) ; R460.2 143.13,38.07 C288.1 C289.1 141.11,38.07 140.49,37.45 140.49,36.83 ; 140.49,36.83 138.47,36.83 138.01,36.37 R454.1 C283.1 R1161.1 134.6,36.37 133.27,37.7 131.39,37.7 131.1,37.99 v1(131.1,38.4) ; 140.49,36.83 v1(140.98,36.34)
+3VPCU_EC_MAIN: length 53.6
  TOP w0.508: 137.16,46.31 R212.2 R213.2 ; v1(118.85,33.37) 119.57,32.65 R1175.2 ; R1178.2 R1177.2 144.59,41.53 v1(144.59,38.62)
  IN2 w0.508: v1(118.85,33.37) 118.9,33.32 119.71,33.32 122.27,35.88 123.09,35.88 125.35,33.62 128.24,33.62 128.6,33.98 131.5,33.98 131.91,33.58 138.95,33.58 140.76,31.77 141.73,31.77 142.5,31 143.72,31 144.38,31.67 v1(144.38,32.16)
  BOTTOM w0.508: v1(141.79,43.82) 141.79,41.54 142.3,41.04 143.4,41.04 144.59,39.86 v1(144.59,38.62) 144.64,38.57 R460.1 145.01,37.39 145.01,32.31 144.85,32.16 v1(144.38,32.16)
+3VPCU_ECPLL: length 4
  TOP w0.203: v1(128.55,41.01) 128.7,40.86 U9.127
  BOTTOM w0.508: v1(128.55,41.01) 128.63,41.01 v1(129.02,40.62) 129.14,40.5 C104.1 L9.1
+3VSUS: length 151
  TOP w0.508: v1(122.96,77.26) 122.96,78.94 119.49,82.41 118.54,82.41 117.88,83.07 117.88,84.1 117.52,84.45 PR183.1 115.49,84.45 PQ32.1
  IN1 w0.508: v1(122.96,77.26) 123.99,76.23 123.99,75.42 124.37,75.05 124.91,75.05 125.12,75.26 127.76,75.26 129.04,73.98 130.04,73.98 130.63,73.39 130.63,73.06 132.21,71.48 132.54,71.48 134.63,69.39 134.95,69.39 136.85,67.49 136.85,61.65 140.14,58.36 140.14,57.62 139.86,57.34 139.86,51 135.27,46.41 135.27,45.22 134.87,44.81 134.87,43.86 133.26,42.25 133.26,41.35 131.96,40.06 128.22,40.06 126.84,41.43 126.16,41.43 125.93,41.2 125.93,39.84 122.76,36.67 118.04,36.67 115.95,34.58 113.13,34.58 111.76,33.21 107.52,33.21 106,31.69 98.5,31.69 98.05,31.24 96.94,31.24 96.7,31.48 93.91,31.48 92.6,30.17 78.38,30.17 77.65,29.43 75.21,29.43 74.46,28.67 62.79,28.67 62.14,29.33 54.48,29.33 v1(54.23,29.07)
  BOTTOM w0.508: R501.1 53.98,27.72 54.23,27.98 v1(54.23,29.07)
+5V: length 58.7
  TOP w0.381: C868.2 15.77,21.16 v1(15.25,20.65)
  TOP w0.508: v1(67.6,104.93) 68.84,103.7 R130.2
  IN1 w1.524: 14.35,87.15 14.35,81.11 14.99,80.48 14.99,75.54 16.24,74.28 18.69,74.28 21.82,71.15 21.82,66.84 14.8,59.82 14.8,53.18
  BOTTOM w0.508: D13.2 D14.2 20.4,84.14 19.33,85.21 17.43,85.21 17.02,85.62 17.02,86.58 16.84,86.76 14.45,86.76 14.1,87.11 14.1,88.69 14.28,88.86 v1(14.71,88.86)
  vias: v1(11.95,27.88) v1(11.95,27.22) v1(12.96,13.45) v1(13.62,13.45) v1(14.28,13.5) v1(14.38,89.46) v1(15.28,89.55) v1(15.35,88.91) v1(15.67,51.57) v1(16,52.16) v1(16.36,51.57) v1(19.1,43.03) v1(19.1,42.37) v1(19.08,41.72) v1(82.25,103.9) v1(82.49,105.1) v1(83.15,105.1) v1(83.81,105.1) v1(115.9,112.03) v1(116.68,112.64) v1(117.32,113.27) v1(117.32,112.56) v1(117.98,113.25) v1(117.97,112.54) v1(148.78,63.09) v1(148.77,62.22) v1(148.78,61.31) v1(149.24,61.76) v1(149.25,63.54) v1(149.26,62.64) v1(150.39,61.48)
+5V_HDD: length 3.1
  TOP w0.762: CN9.16 155.47,66.05 ; CN9.15 155.12,64.78 ; CN9.14 154.94,63.51
  vias: v1(137.93,63.04) v1(137.93,62.38) v1(138.59,63.04) v1(138.59,62.38) v1(139.26,63.04)
+5V_S5: length 84.1
  TOP w0.508: v1(123.72,46.48) 123.72,47.11 PR108.1 ; v1(38.72,59.22) 39.4,59.22 PR166.1 ; v1(29.84,47.86) 29.84,47.7 C866.1 ; v1(39.55,78.76) 39.85,78.45 39.85,77.71 39.07,76.93 37.09,76.93 36.32,76.16 34.91,76.16 34.37,75.62 34.37,71.21 35.33,70.25 37.55,70.25 PR170.1 37.86,69.04 v1(37.42,68.6) ; R407.1 R410.1 v1(140.47,96.24) ; PR57.1 124.7,58.1 v1(125.33,57.47)
  IN1 w0.508: v1(140.47,96.24) 140.62,96.24 142.56,98.17 142.56,104.64 143.78,105.87 143.78,108.77 142.72,109.84 v1(142.72,110.2)
  IN2 w0.508: v1(37.42,68.6) 36.81,67.99 36.81,67.22 38.2,65.83 38.2,64.07 38.08,63.95 38.08,63.24 38.99,62.32 38.99,61.61 38.48,61.1 38.48,59.46 v1(38.72,59.22) ; v1(41.25,84.05) 40.95,84.05 40.67,83.76 40.67,82.72 39.68,81.73 39.68,78.88 v1(39.55,78.76)
  BOTTOM w0.203: PU7.12 30,49.7 29.91,49.61
  BOTTOM w0.381: v1(117.65,50.97) 118.1,51.42 PR75.1 ; 29.91,49.61 29.23,48.93 PC107.1
  BOTTOM w0.508: v1(41.25,84.05) PR177.2 PR45.1 ; PR185.2 PR53.1 124.63,58.17 v1(125.33,57.47) ; PC107.1 29.64,48.25 29.84,48.05 v1(29.84,47.86) ; v1(34.29,57.37) 37.97,57.37 38.41,57.8 38.41,58.9 v1(38.72,59.22) 38.96,59.22 40.47,57.7 46.5,57.7 47.75,58.95 47.75,59.96 48.13,60.34 48.13,61.44 PR153.1
  vias: v1(107.02,109.64) v1(107.68,109.64) v1(108.1,110.86) v1(108.34,109.64) v1(108.35,108.99) v1(109.01,109.64) v1(109,108.99) v1(131.14,102.64) v1(131.14,101.98) v1(131.79,102.64) v1(131.79,101.98) v1(132.43,102.64) v1(132.43,101.98) v1(142.72,112.21) v1(142.72,111.55) v1(142.72,110.89) v1(156.21,108.42) v1(156.21,107.76) v1(156.54,109.01) v1(156.87,108.42) v1(156.87,107.76) v2(18.19,56.49) v2(18.19,55.74) v2(18.95,55.8) v2(19.79,55.88)
+5VA: length 1
  TOP w0.203: 4.62,19.85 4.88,19.6 U4.26
  vias: v1(4.45,22.95) v1(4.45,22.24) v1(4.73,21.22) v1(8.52,27.84) v1(8.52,27.18)
+5VPCU: length 8.8
  TOP w0.508: PR9.1 119.3,101.87 v1(119.38,101.95)
  IN1 w0.508: v2(119.91,109.43) 118.97,108.49 118.97,104.26 119.38,103.85 v1(119.38,101.95)
  vias: v1(111.84,106.9) v2(119.13,113.5) v2(119.13,112.61) v2(119.89,113.5) v2(119.89,112.61) v2(119.89,111.85) v2(120.64,113.47) v2(120.65,112.61) v2(121.41,113.5) v2(121.41,112.61)
+15V: length 68.2
  TOP w0.254: PR178.1 114.08,93.15 v1(114.02,93.21) ; PR162.1 144.76,91.63 v1(144.7,91.58) ; v1(97.63,99.56) 98.03,99.16 PR143.1 ; PR201.1 97.66,103.98 v1(97.16,103.47)
  IN1 w0.254: v1(97.16,103.47) 97.63,102.99 97.63,99.57 v1(97.63,99.56) 98.23,98.96 98.77,98.96 100.72,97.01 100.72,93.96 101.37,93.31 113.92,93.31 v1(114.02,93.21) 115.72,93.21 116.55,92.38 117.77,92.38 118.36,92.98 122.19,92.98 122.83,92.34 122.83,87.9 125.27,85.47 138.59,85.47 v1(144.7,91.58)
+A3VPCU: length 4.2
  TOP w0.203: v1(141.15,29.02) 141.23,29.1 U9.74
  BOTTOM w0.203: C118.1 142.22,27.64 L11.2 141.15,28.53 v1(141.15,29.02)
+PVCC_VGG: length 3.9
  TOP w0.203: PC152.2 122.46,56.16 122.46,55.67 122.74,55.4 PU6.21
  TOP w0.508: PC152.2 PR57.2
+VCC_CORE: length 6.5
  TOP w0.254: 47.8,81.55 46.2,83.15 42.66,83.15 PR147.2
  vias: v1(47.85,79.01) v1(66.47,69.74) v1(66.47,68.93) v1(67.23,69.74) v1(67.23,68.93) v1(68.75,68.12) v1(70.26,70.48) v1(71.01,69.73) v1(71.02,68.15) v1(71.78,69.72) v1(71.78,68.15) v2(48.82,80.86) v2(48.82,79.97) v2(49.58,81.24) v2(49.58,80.36) v2(49.58,79.59) v2(51.31,81.12) v2(51.31,80.36) v2(51.31,79.59) v2(51.41,78.6)
+VCC_VGG: length 11.6
  TOP w0.203: PU6.6 123.54,49.65 123.59,49.6 v1(123.59,49.24) PR108.2
  IN1 w0.254: v1(123.59,49.24) 122.9,49.93 121.13,49.93 120.04,51.02 118.97,51.02 118.01,51.98 v1(116.71,51.98)
  BOTTOM w0.254: PR87.1 117.1,51.6 v1(116.71,51.98) ; PC161.2 v1(123.59,49.24)
+VDDQ_VTT: length 31.2
  IN2 w1.524: 34.39,47.87 34.39,47.34 33.73,46.68 33.73,44.15 33.13,43.54 33.13,37.22 40.33,30.02 49.38,30.02
  BOTTOM w0.203: v1(34.24,49.95) 34.09,50.1 PU7.3
  vias: v1(34.21,52.09) v1(34.19,51.43) v1(34.24,49.29) v1(50.43,29.18) v1(50.67,29.78) v1(51.09,29.18) v1(52.48,29.2)
+VDDQ_VTT_M0_M1_R:
  vias: v1(53.53,34.74) v1(54.91,34.74) v1(88.96,35.03) v1(89.79,35.05) v1(90.9,35.02) v4(51.86,34.86)
+VIN: length 102.3
  TOP w0.254: v1(128.14,92.93) 129.93,92.93 PR167.1
  TOP w0.508: PR190.1 113.23,93.51 113.64,93.92 115.44,93.92 PR186.1 116.37,93.31 v1(116.99,93.31) ; v1(114.37,33.67) 113.72,33.67 113.01,34.38 PD1.2 111.68,34.38 C877.1 ; v1(119.81,107.66) 119.31,107.16 PR144.1 ; C866.2 29.95,46 v1(29.19,46)
  TOP w5.08: 23.27,56.91 23.27,61.08 23.57,61.38 23.57,61.7 23.6,61.73 23.6,64.13 23.57,64.17 23.57,71.52 26.35,74.3 26.35,78.64
  IN1 w0.254: v1(131.94,62.77) 131.94,60.49 130.92,59.47 130.92,57.49 130.58,57.15 126.81,57.15 v1(125.58,55.92)
  IN1 w0.508: v2(127.23,98.11) 127.23,97.32 125.65,95.75 121.62,95.75 121.08,95.21 119.3,95.21 117.4,93.31 v1(116.99,93.31)
  IN2 w0.508: v1(103.92,109.94) 103.92,110.58 104.61,111.27 111.06,111.27 113.95,108.37 118.62,108.37 119.33,107.66 v1(119.81,107.66) 120.88,107.66 121.62,106.92 121.62,103.54 124,101.15 127.42,101.15 127.89,100.68 v2(127.89,100.45)
  BOTTOM w0.108: PR136.2 26.93,86.4 26.85,86.48 24.78,86.48 PR140.2
  BOTTOM w0.254: v1(128.14,92.93) 127.64,92.93 127.26,93.31 127.26,97.55 ; PR191.1 126.01,56.35 v1(125.58,55.92)
  vias: v1(23.14,53.03) v1(23.78,53.25) v1(26.16,84.83) v1(26.16,84.09) v1(26.16,83.35) v1(26.75,84.47) v1(26.75,83.71) v1(26.75,82.9) v1(27.33,84.8) v1(27.33,84.06) v1(27.36,83.33) v1(27.36,82.67) v1(27.94,84.47) v1(27.94,83.68) v1(27.94,82.97) v1(34.67,89.65) v1(43.74,90.24) v1(53.72,92.8) v1(53.72,92.04) v1(54.48,92.8) v1(54.48,92.04) v2(19.82,52.8) v2(20.58,52.72) v2(20.73,53.46) v2(21.36,52.7) v2(21.49,53.48) v2(22.07,53) v2(85.45,22.21) v2(85.45,21.46) v2(85.45,20.71) v2(85.45,19.96) v2(86.2,22.21) v2(86.2,21.46) v2(86.2,20.71) v2(86.2,19.96) v2(127.13,100.45) v2(127.2,99.08) v2(127.86,99.58) v2(127.94,98.57) v2(133.89,102) v2(133.87,101.25) v2(134.62,101.25) v2(134.66,102) v2(135.37,101.25) v2(136.15,65.99) v2(136.15,65.23) v2(136.15,64.47) v2(136.15,63.7) v2(136.15,62.94) v2(138.89,112.14) v2(139.66,112.16) v2(140.44,112.16) v2(141.23,112.16) v2(141.99,112.14)
+VIN_VCORE: length 2.7
  TOP w0.508: PR51.1 33.75,68.32 33.12,68.32 32.61,68.82 32.61,69.23 v1(33.1,69.71)
  vias: v1(33.3,72.08)
DVDD: length 7.2
  TOP w0.508: Q77.3 26.21,31 v1(31.47,31)
  BOTTOM w0.508: R1144.2 30.41,29.95 v1(31.47,31)
GND: length 784.6
  TOP w0.076: CN5.18 159.56,107.5 159.34,107.28 159.34,105.71 v1(159.21,105.58)
  TOP w0.152: v1(140.34,44.64) 140.34,44 v1(139.75,43.41) 139.71,43.36 139.71,41.19 139.1,40.58 138.02,40.58 137.9,40.46 U9.104 v1(137.9,38.37)
  TOP w0.178: U9.91 141.19,35.9 v1(140.98,35.69)
  TOP w0.203: v1(113.03,29.25) 113.44,28.84 113.84,28.84 114.18,28.51 U21.12 ; PU6.19 123.54,55.91 v1(123.75,56.12) ; 134.49,22.74 134.7,22.95 U9.49 ; v1(110.36,23.87) 110.47,23.98 U21.16 ; C326.1 115.18,29.03 U21.10 ; U21.15 110.08,24.48 109.73,24.12 109.73,23.89 v1(109.7,23.87) ; v1(112.37,29.2) 112.37,29.1 113.68,27.79 U21.13 ; U21.5 115.68,22.52 116.21,21.99 118.03,21.99 119.08,23.03 v1(119.08,23.1) ; C258.1 114.67,59 U15.1 ; v1(125.08,27.99) 125.58,27.5 U9.27
  TOP w0.254: U27.J8 101.4,45.76 v3(101.03,45.38) ; PQ36.1 97.75,32.14 v1(97.61,32.28) ; v3(89.57,43.72) 89.57,43.32 C779.2 ; Q13.4 148.96,36.74 v1(149.52,36.18) ; U24.B9 49.37,51.38 v3(49.81,51.83) 49.71,51.83 U24.A9 ; C211.1 77.59,74.99 77.95,75.34 v1(77.95,75.34) ; v1(96.01,29.94) 96.17,29.94 96.45,29.65 PQ36.4 ; v3(96.18,49.37) 96.58,48.97 U27.E2 ; U27.E8 101.18,49.19 101.17,49.19 v3(101,49.37) 101.18,49.54 U27.D8 ; MR3.2 140.3,104.25 v1(140.22,104.33) ; PR149.1 47.02,83.66 v1(47.09,83.72) ; U25.B9 67.19,51.37 v3(67.65,51.83) 67.47,52.01 67.3,52.01 U25.A9 ; U27.A9 102.3,52.17 v3(102.64,51.83) 102.2,51.38 U27.B9 ; 95.16,52.01 v1(94.43,52.01) ; U25.J8 66.35,45.75 v3(65.95,45.36) ; v1(150.19,40.78) 150.26,40.72 Q13.1 ; C326.1 115.9,29.17 v1(116,29.28)
  TOP w0.305: PC153.1 129.77,56.28 128.99,55.5 PC156.1 ; v3(95.34,47.74) 95.72,47.37 U27.G1 ; U27.E1 v3(95.4,48.57) ; U24.G1 42.89,47.37 v3(42.51,47.74) ; v3(43.37,49.41) 43.77,49.01 U24.E2 ; v3(43.37,49.41) 43.01,49.77 U24.D1 ; v3(43.37,49.41) 42.97,49.01 U24.E1 ; C228.2 84.78,68.5 v1(84.82,68.54) ; v3(44.14,50.95) 44.56,51.37 U24.B3 ; v3(77.64,51.75) 77.86,51.53 78.02,51.37 U26.B1 ; v1(79.3,78.11) 79.88,78.69 R349.2 ; U26.M9 84.79,42.99 v3(84.82,42.99) ; v3(41.99,50.77) 42.59,51.37 U24.B1 ; U27.J2 v3(96.98,45.39) ; U27.G8 101.4,47.34 v3(101.81,46.93) 102.2,47.32 U27.G9 ; U24.J8 48.45,45.65 48.42,45.65 v3(48.17,45.4) ; v3(60.34,51.73) 60.37,51.73 60.73,51.37 60.74,51.37 U25.B1 ; U27.D1 95.8,49.75 v3(96.18,49.37)
  TOP w0.33: U24.M9 49.51,43.22 v3(49.77,42.97) ; U25.P9 67.15,41.77 v3(66.75,42.17) ; U25.G1 60.75,47.37 v3(61.14,47.77) ; U25.J2 61.91,45.4 v3(61.94,45.4) ; U25.G8 66.38,47.37 v3(66.78,47.77) ; U24.G9 49.37,47.35 v3(48.97,46.96) U24.G8 ; U25.E2 v3(61.14,49.37) U25.D1 ; U25.M9 67.54,42.97 v3(67.55,42.97) ; U25.E1 60.55,49.16 60.55,49.21 v3(60.33,49.42) ; v3(66.75,49.37) 66.74,49.37 66.52,49.15 66.52,49.14 U25.E8 ; U25.B3 62.53,51.55 v3(63.11,51.55) ; U27.F9 102.2,48.17 v3(102.63,48.59) ; U24.M1 42.92,43.37 v3(42.55,42.99) ; U24.E8 48.41,49.12 48.41,49.12 v3(48.17,49.37) 48.34,49.54 48.34,49.54 U24.D8 ; U25.D8 65.95,49.37 v3(65.95,49.37) ; v3(60.33,42.94) 60.75,43.36 U25.M1 ; U25.T9 67.39,39.92 67.39,39.92 67.54,39.77 v3(67.55,39.77) ; v3(67.59,47.73) 67.5,47.73 U25.G9 67.43,47.08 v3(67.62,47.08) ; v3(60.1,40.43) 60.36,40.17 U25.T1 ; v3(61.13,41.37) 61.13,41.38 60.87,41.65 U25.P1 ; v3(49.77,48.57) 49.37,48.17 U24.F9
  TOP w0.343: U26.B9 84.46,51.37 v3(84.92,51.83) 84.82,51.83 84.48,52.17 U26.A9 ; U27.B1 95.16,52.01 ; v3(97.02,50.97) 97.04,50.99 97.04,51.01 U27.B3
  TOP w0.356: U26.J8 83.63,45.77 v3(84.03,45.37) ; U26.J2 79.2,45.38 v3(79.21,45.38) ; U26.E8 83.4,49.19 83.39,49.19 v3(83.22,49.37) ; v3(44.14,45.37) 43.77,45.74 U24.J2 ; v3(95.14,40.37) 95.35,40.17 U27.T1 ; U26.P9 84.48,41.77 84.88,41.37 v3(84.88,41.27) ; v3(49.82,41.37) 49.42,41.77 U24.P9 ; U27.T9 102.2,40.13 v3(101.81,39.74) ; U26.M1 77.61,42.96 v3(77.61,42.94) ; v3(84.9,47.08) 84.7,47.08 U26.G9 ; v3(42.57,39.77) 42.78,39.98 42.78,39.98 U24.T1 ; v3(84.02,49.37) 83.79,49.59 83.79,49.59 U26.D8 ; v3(77.61,49.42) 77.61,49.38 U26.E1 ; U24.T9 49.37,40.13 v3(48.97,39.74) ; U26.B3 79.99,51.74 v3(79.99,51.76) ; U26.E2 78.42,49.37 v3(78.42,49.37) U26.D1 ; U26.T9 v3(84.82,39.77) ; U27.P1 95.8,41.76 v3(96.2,41.37) ; v3(84.06,47.77) 83.85,47.56 83.81,47.56 U26.G8 ; v3(77.62,42.16) 78.02,41.77 U26.P1 ; v3(66.78,47.77) 67.15,48.13 U25.F9 ; v3(102.73,43.42) 102.67,43.37 U27.M9 ; v3(77.24,40.13) 77.28,40.17 U26.T1 ; U26.G1 77.62,47.77 v3(77.62,47.77) ; v3(84.82,47.77) 84.81,47.77 U26.F9 ; v3(43.37,41.37) U24.P1 ; v3(102.62,41.39) 102.24,41.77 U27.P9 ; v3(95.13,42.96) 95.54,43.37 U27.M1
  TOP w0.381: v1(102.53,110.14) 103.14,110.74 PR219.2 ; v1(140.22,104.99) 140.22,104.99 C575.1 D30.2 ; v1(106.39,109.77) 106.39,109.48 PC163.1 ; 134.49,22.74 133.95,22.2 C124.2 ; v1(94.31,18.89) 94.31,19.56 PC103.1 ; R104.1 67.61,95 v1(67.25,94.65) ; v1(99.57,18.89) 99.82,18.63 100.97,18.63 PR124.1 ; v1(70.38,75.99) 70.53,75.84 C166.1 ; C191.1 67.19,76.18 v1(67.19,75.21) ; v1(102.86,24.7) 102.64,24.49 PC100.1 ; C214.2 74.81,73.79 75.5,74.47 C163.1 75.52,74.62 76.15,75.25 v1(76.15,75.35) 76.15,75.43 75.8,75.78 C215.1 ; C330.1 C329.1 v1(44.97,17.99) ; v1(156.85,109.64) 157.26,110.06 C41.1 ; v1(62.71,73.43) 62.71,73.65 63.31,74.25 C156.1 ; C869.1 48.59,59.89 v1(48.45,59.76) ; C216.2 77.25,72 v1(77.25,72.56) 77.23,72.56 77.05,72.74 C220.1 ; v1(13.41,14.3) 13.41,14.31 C53.2 ; R1012.1 139.04,73.19 v1(138.84,73.39) ; C243.1 65.36,66.38 v1(65.56,66.58) ; C730.2 70.19,51.58 v1(69.91,51.3) ; R333.2 64.27,81.35 v1(64.64,80.97) ; C152.2 66.42,77.34 v1(66.56,77.47) 66.6,77.43 C208.1 ; v1(75.36,82.85) 75.36,82.44 75.06,82.13 C155.1 ; PC160.2 119.46,46.7 v1(120.08,47.32) 119.58,47.83 PC159.2 ; PC109.2 95,18.47 v1(95,18.89) ; v1(75.25,48.96) 75.09,49.12 C714.2 ; v1(74.81,71.28) 74.81,71.08 C227.1 ; v1(71.4,58.11) 71.69,58.39 R422.2 ; PC108.1 97.16,18.16 v1(97.16,18.89) ; C209.1 69.35,75.16 v1(69.52,75.33) 69.56,75.28 C180.1 ; C725.2 49.7,54.15 v1(49.59,54.04) ; v1(73.34,42.61) 73.64,42.31 C715.2 ; v1(65.51,85.16) 65.92,85.16 C158.1 ; PR200.2 118.16,50.51 v1(117.65,50) 118.1,49.55 PC76.2 ; v1(80.96,79.3) 81.54,78.72 R346.1 ; PC164.2 96.01,29.71 v1(96.01,29.94) ; C297.2 124.86,27.77 v1(125.08,27.99) ; v1(130.36,56.62) 130.1,56.35 PC153.1 ; C867.1 27.99,59.31 v1(27.99,59.93) ; C597.2 157.25,101.05 v1(156.95,100.75) ; C249.1 70.23,68.97 69.47,69.73 C251.2 ; v1(80.8,68.56) 80.41,68.17 R200.2 ; C244.1 65.18,68.93 v1(65.56,68.56) ; R352.1 65.24,77.8 v1(65.56,77.49) ; C255.1 62.62,66.37 62,65.75 v1(62,65.66) ; v1(75.92,37.03) 75.67,36.78 C720.1 ; v1(40.79,17.97) 40.78,17.99 C594.2 ; C754.2 93.02,55.4 v1(92.87,55.25) ; v1(72.35,62.1) 72.23,62.1 71.87,62.46 C284.2 ; v1(65.57,78.9) 65.46,78.78 C183.1 ; v1(62.03,78.27) 61.93,78.16 C153.1 ; C716.2 73.66,40.28 v1(73.38,40) ; v1(75.25,47.31) 75.09,47.46 C774.2 ; v1(68.99,97.25) 68.84,97.39 C73.2 ; v1(69.52,73.65) 70.09,73.65 R386.1 ; C320.2 v1(43.19,18.35)
  TOP w0.457: C22.1 15.37,50.95 v1(15.27,51.06) ; v1(3.51,15.4) 3.12,15.8 C52.2 ; C50.1 14.82,18.65 v1(14.79,18.62) C49.2 ; v1(11.02,32.62) 10.78,32.86 C23.2 ; R1203.1 15.76,32.65 v1(16.27,32.14) 15.84,31.71 C76.1 ; R210.2 R1165.1 ; C782.2 88.05,33.72 v1(88.03,33.7) ; C55.2 15.47,16.82 15,16.82 v1(14.61,17.21) 14.24,17.58 R74.1 ; R339.2 18.55,40.96 v1(19.07,40.44) ; C781.2 91.06,33.27 v1(90.78,33.54) ; C58.2 5.2,13.67 v1(5.43,13.9) ; C780.2 86.92,33.51 v1(86.73,33.7) ; C784.2 95.14,33.29 v1(95.55,33.7) ; v1(133.69,21.31) 133.69,21.52 133.95,21.78 C124.2 ; C783.2 93.73,33.27 v1(94.17,33.7)
  TOP w0.508: C871.1 v1(74.02,35.13) ; v1(110.33,89.39) 109.71,88.76 PQ20.1 ; v1(65.66,73.62) 65.15,74.13 C149.1 ; C595.1 153.33,96.74 152.52,96.74 152.3,96.95 v1(152.3,97.02) ; v1(156.77,106.04) 156.68,105.95 MR1.3 ; v1(115.44,48.1) 115.7,47.85 R1188.1 ; C576.1 144.76,104.57 v2(144.76,104.13) ; C258.1 115.1,59.43 v2(115.8,59.43) ; C170.2 83.99,79.98 82.56,79.98 v1(82.34,80.2) ; v1(113.72,60.24) 113.36,60.59 PC144.2 ; v1(70.44,79.04) 70.88,79.04 C151.1 ; v1(157.33,92.5) 157.13,92.29 156.44,92.29 156.21,92.52 C133.1 C132.1 ; v1(112.85,88.59) 113.34,88.1 PQ31.1 ; R366.2 61.48,75.51 v1(61.27,75.3) ; Q7.1 v1(12.09,31.46) ; R368.1 61.7,69.55 v1(61.29,69.55) ; v1(18.62,22.27) 18.76,22.12 C814.2 C819.2 19.78,21.93 v1(19.36,22.36) ; v1(79.43,72.44) 78.9,72.98 D44.1 C204.2 ; C768.1 106.4,35.91 v1(106.48,35.83) ; v1(40.34,20.62) 40.34,21.28 39.93,21.68 Q42.1 ; C171.2 158.3,105.58 v1(158.52,105.58) ; v1(121.92,23.99) 121.92,24.32 121.4,24.84 R514.1 ; C739.2 39.82,50.67 v1(39.88,50.61) ; C241.1 46.1,72.05 v1(46,72.15) ; C142.2 78.24,84.08 v1(77.83,84.5) 77.98,84.65 C160.1 ; C294.2 145.17,100.88 v1(145.59,101.3) ; C694.1 153.43,97.95 v1(152.86,97.37) ; C154.1 70.55,78.37 v1(70.44,78.37) ; R1193.1 112.23,40.64 v1(111.87,40.28) 111.29,40.86 R174.1 ; PR34.2 127.88,93.68 v1(127.76,93.56) ; PR141.2 118.99,103.99 119.25,104.26 v2(120.02,104.26) ; C316.1 112.09,53.77 112.44,53.77 v1(112.66,53.99) ; v1(61.29,67.5) 61.33,67.54 C603.2 ; C335.2 121.24,23.89 v1(121.26,23.87) ; C334.2 120.64,77.3 v1(120.69,77.25) ; U37.2 v1(138.69,56.01) ; v1(54.74,86.05) 55.51,85.27 C157.2 ; PQ34.1 v1(98.3,106.64) ; Q78.1 21.21,31.97 v1(20.7,31.97) ; PR189.2 111.33,91.95 v2(110.94,91.56) ; R340.2 73.73,82.98 v1(73.27,82.98) ; v1(24.76,46.87) 24.89,46.74 PC171.1 ; C47.2 107.08,42.65 v1(106.58,42.15) 106.04,42.69 C766.2 ; v1(156.79,101.93) 156.2,101.34 D12.2 ; v1(121.86,21.31) 121.59,21.03 C323.2 ; PQ35.1 100.61,100.75 101.12,100.24 v1(101.12,100.17) ; C722.1 41.64,36.57 v1(41.09,36.01) ; v1(46.83,64.66) 46.27,64.1 PR23.2 PC34.2 ; v1(58.04,74.59) 59.64,74.59 C194.1 ; v1(71.93,50.99) 71.98,50.95 C770.1 ; C261.1 85.46,63.86 84.81,64.51 v1(84.81,64.67) 84.48,64.35 C248.1 ; C717.2 84.73,37.36 v1(85.03,37.66) ; R361.1 75.08,78.33 v1(74.33,79.07) 74.7,79.44 C164.1 ; C762.2 106.16,55.47 v1(106.43,55.21) ; v1(90.61,62.78) 90.61,62.31 90.9,62.03 C143.1 ; C275.1 115.9,52.28 116.3,52.68 v1(116.3,53.43) ; v2(120.5,100.65) 120.55,100.7 120.55,100.93 120.6,100.98 PQ22.1 ; v1(106.94,40.02) 106.76,40.02 106.18,39.44 C755.2 ; v1(144.73,90.44) 145.19,90.44 145.51,90.12 PC133.1 PC130.1 ; C733.2 C732.2 39.16,44.01 v1(39.8,43.38) ; v1(64.97,99.61) 64.76,99.4 C74.1 C78.2 ; C573.1 142.01,107.71 v1(142.47,107.25) 142.01,106.79 D29.2 ; v1(34.67,64.23) 34.67,64.88 34.56,64.99 34.56,66.19 PC147.1 ; C728.2 v1(71.58,39.83) ; PC128.1 145.76,93.28 v1(145.77,93.29) ; C724.1 v1(70.31,36.6) ; v1(129.03,96.26) PC52.1 ; v1(74.7,18.86) 74.7,18.56 74.44,18.29 PC167.2 ; v1(73.4,76.12) 72.9,76.62 R369.1 ; v1(131.32,44.68) 131.95,44.04 R210.2 ; C877.2 111.24,35.74 111.76,36.26 PQ24.1 113.07,35.87 v1(114.42,35.87) ; v1(118.1,55.32) 118.09,55.31 PC154.1 ; v1(29.69,54.27) 29.89,54.08 PC102.2 PC101.2 ; C222.1 57.44,66.05 v1(58.01,66.61) ; v1(43.99,73.04) 44.32,72.71 PC135.1 ; R421.2 71.71,64.53 71.38,64.86 C268.2 C269.2 72.71,64.86 v1(73.36,64.86) ; R100.2 77.64,78.19 v1(77.23,78.19) ; v1(105.44,46.45) 105.85,46.04 C775.2 ; v1(109.14,56.1) 109.35,55.9 C870.1 ; C799.1 32.65,61.92 v1(32.79,62.07) ; v1(97.98,54.68) 98.05,54.75 C760.2 ; PR142.2 118.04,107.16 v2(117.65,106.77) ; C169.2 85.9,79.83 v1(85.9,79.7) ; C236.1 60.67,67.7 v1(60.55,67.58) 60.55,66.54 C234.1 ; v1(110.03,101.52) 109.81,101.31 R317.1 ; Q10.1 71.88,102.33 70.41,100.85 v1(70.41,100.24) ; v1(118.34,36.02) 118.15,36.02 PQ16.1 ; C736.2 47.95,36.42 v1(47.9,36.46) ; v1(21.87,93.16) 21.87,93.13 20.89,92.15 PQ1.4 ; C30.2 13.66,23.81 v1(14.15,24.3) 14.55,23.91 R32.1 ; PD10.2 v1(70.87,19.74) ; v1(122.71,27.57) 122.71,27.35 123.29,26.76 R254.2 ; PC127.1 98.3,96.48 97.89,96.89 v1(97.48,96.89) 97.28,96.7 PQ23.1 ; PC168.2 PR224.1 68.1,18.29 v1(67.72,18.68) ; C168.2 82.63,81.18 v1(82.5,81.18) ; C703.2 v1(70.13,47.34) ; v1(96.07,65.65) 96.06,65.66 96.06,66.29 C247.1 ; R1048.1 v1(69.92,41.99) ; C223.1 50.38,65.95 50.27,66.06 v1(49.68,66.06) ; 13.97,85.53 13.21,85.53 v1(12.96,85.28) ; C861.2 109.21,50.7 v1(109.28,50.77) ; v1(138.46,51.3) 139.47,52.31 C859.2 ; v1(79.1,82.83) 79.32,82.61 C173.2 ; R1104.1 102.13,36.04 v1(102.13,36.04) ; R400.2 141.13,97.81 v1(141.12,97.8) ; 106.01,89.63 106.63,89 v1(106.63,88.59) ; v1(47.73,67.32) 48.34,67.32 C239.1 ; v1(68.61,99.61) 68.84,99.37 C71.1 ; C221.1 59.25,66.07 59.87,66.69 v1(59.87,67.57) ; v1(60.66,78.27) 60.39,78.54 C162.1 ; v1(55.88,72.05) 56.28,72.45 C238.1 ; v1(40.32,40.71) 40.19,40.84 C737.2 ; v1(57.81,72.5) 57.86,72.45 C235.1 59.59,72.45 R113.1 ; v1(69.98,44.92) 70.33,44.57 C734.2 71.12,44.42 C735.2 ; v1(37.49,76.29) PC146.1 ; C262.1 75.19,63.51 74.49,62.81 v1(74.33,62.81) ; C224.1 68.67,71.3 68,70.64 C242.1 68.13,70.24 68.64,69.73 v1(68.76,69.73) 68.77,69.73 C251.2 ; PR211.1 110.61,60.43 111.53,59.51 v2(111.92,59.51) ; R1121.1 34.38,60.81 v1(34.88,61.31) ; v1(62,68.67) 62.6,68.67 C245.1 ; v1(88.65,99.33) 88.04,99.94 PQ18.1 ; v1(148.54,53.3) 148.34,53.3 148.16,53.12 C865.1 ; v1(87.76,22.27) 87.76,21.5 C878.2 ; C710.2 56.05,32.34 C708.2 v1(57.68,33.24) ; R1078.1 v1(85.82,35.33) ; C751.2 96.21,54.63 v1(96.09,54.5) ; C860.2 v1(142.03,56.76) ; v1(96.47,34.79) 97.2,34.79 C786.2 ; C217.2 65.67,72.82 v1(65.69,72.8) 66,73.11 C195.2 66.79,72.61 C192.1 ; v1(149.39,43.35) 149.06,43.03 149.06,42.81 C126.2 ; v1(84.81,80.56) 84.81,80.22 C193.1 ; v1(122.99,58.86) 122.99,58.3 PC152.1 ; C331.1 119.64,79.13 v1(118.94,79.83) ; v1(86.59,79.64) 86.73,79.64 C161.2 ; PR5.2 17.48,93.67 v1(17.65,93.84) ; C60.2 v1(3.82,13.91) ; C178.2 57.49,77.48 58.12,76.85 v1(58.12,76.67) 58.2,76.59 C179.2 ; R1046.1 v1(50.75,34.89) ; C707.2 v1(49.34,34.02) ; v1(120.07,85.24) 120.07,84.74 119.94,84.61 PQ30.1 ; C839.2 v1(59.15,95.01) ; PD9.2 v1(72.65,19.66) ; v1(72.52,45.43) 72.52,45.56 72,46.08 C748.2
  VCC w0.089: 61.43,60.5 61.7,60.77 ; 78.03,60.39 78.39,60.39 ; 64.37,47.44 64.37,47.16
  VCC w0.102: 101.65,48.22 101.93,48.22 ; 62.34,47.13 62.34,46.78 ; 101.6,45.76 101.98,45.76
  GND w0.102: 98.53,36.83 98.86,36.83
  BOTTOM w0.064: 119.36,79.24 119.5,79.09 119.5,78.65 U20.N2 120,78.65 120,79.16 119.91,79.24
  BOTTOM w0.076: U7.B52 59.64,82.01 59.84,82.06 59.97,82.18
  BOTTOM w0.102: U7.AJ1 U7.AJ3 ; 59.97,82.18 60.02,82.24
  BOTTOM w0.108: 119.71,79.44 119.91,79.24 ; C48.2 55.99,35.26 v1(55.75,35.02)
  BOTTOM w0.152: v1(57.96,59.33) 58.17,59.33 58.4,59.57 58.43,59.57 U7.BG53
  BOTTOM w0.178: v1(85.13,75.48) 85.01,75.36 U7.R1
  BOTTOM w0.203: PU7.10 31.18,48.23 30.87,47.92 v2(30.58,47.92) ; U7.A6 81.95,82.42 81.95,83.23 v1(81.81,83.37) ; PU4.19 40.09,68.18 39.56,68.71 v1(39.55,68.71) ; C319.1 109.26,55.31 110.03,55.31 110.12,55.4 U19.1 ; PU7.7 32.38,47.8 v1(32.54,47.64) ; v1(59.54,82.9) 59.77,82.9 60.02,82.64 60.02,82.24 ; v1(115.32,98.69) 115.32,98.77 114.97,99.12 PU1.15 ; PU7.4 32.57,49.7 v1(32.47,49.61) ; v1(82.93,76.33) 82.92,76.31 U7.P4
  BOTTOM w0.216: U7.BH52 U7.BG53
  BOTTOM w0.229: v1(64.64,80.97) 64.42,80.97 U7.D42 ; v1(69.29,82.82) 69.46,82.66 U7.A31 ; v1(65.52,58.12) 65.57,58.16 U7.BJ39 ; U7.BJ15 v1(77.23,58.11) ; U7.AE53 57.96,70.5 v1(57.84,70.63) ; U7.A43 63.63,82.7 v1(63.35,82.97) ; v1(84.82,68.54) 84.81,68.56 U7.AJ1
  BOTTOM w0.254: R439.2 104.83,84.95 105.13,84.65 105.38,84.65 105.66,84.38 Q38.1 ; U7.A23 73.34,82.9 v1(73.27,82.98) ; U7.BG38 65.72,60.1 v1(65.57,60.1) 65.42,60.1 U7.BG40 ; v1(82.64,83.14) 82.55,83.06 82.55,82.33 U7.A5 ; U7.A19 75.29,82.77 v1(75.36,82.85) ; v3(67.65,51.83) 67.19,51.37 U25.B9 ; U7.C3 82.57,81.18 v1(82.5,81.18) ; v1(82.93,67.57) 82.57,67.15 U7.AM4 ; v1(109.87,44.01) 109.97,43.92 Q35.1 ; U7.D16 77.13,81.03 v1(77.23,81.03) ; v1(80.14,77.24) 80.44,76.94 U7.M9 80.01,76.4 80.01,76.12 U7.P10 ; v1(80.2,59.98) 80.27,59.97 U7.BG7 ; v1(58.04,74.59) 58.24,74.39 U7.U53 ; Q38.4 106.96,81.28 107.32,80.91 v1(107.32,80.73) ; v1(88.65,99.33) 88.65,99.51 88.38,99.77 PQ39.1 ; v1(84.79,61.03) 84.62,61.21 U7.BD1 ; U7.K12 79.03,77.84 v1(79.3,78.11) ; U7.BF50 59.78,60.34 v1(59.72,60.4) ; v1(79.1,82.83) 79.17,82.76 U7.A11 ; CN5.39 157.31,102.25 156.99,101.93 v1(156.79,101.93) ; U11.2 131.14,81.63 131.34,81.83 131.34,82.62 v1(130.58,83.38) ; U7.BJ11 v1(79.17,58.08) ; v1(73.36,57.39) 73.34,57.41 U7.BJ23 ; v1(58.01,61.03) 58.18,61.21 U7.BD53 ; CN5.51 156.95,99.25 v1(156.95,99.25) ; v1(77.09,82.85) 77.09,82.77 77.23,82.62 77.23,82.32 U7.A15 ; v1(74.88,94.66) 74.91,94.66 75.25,95 CN10.29 ; C746.2 52.89,48.23 v1(51.05,48.23) ; U7.BJ7 81.08,58.21 v1(81.09,58.15) ; v1(85.07,70.51) 85.07,70.5 U7.AE1 ; U7.D40 65.03,80.64 v1(64.67,80.28) ; v1(60.78,60.38) U7.BG49 ; U24.B9 49.81,51.81 ; U7.J53 57.96,78.27 v1(57.51,78.73) ; v1(72.82,96.87) 72.57,96.87 72.25,96.55 CN10.23 ; Q35.4 111.27,39.76 v1(110.55,39.04) ; U7.A47 61.72,82.37 61.72,82.79 v1(61.6,82.92) ; v1(89.92,104.49) 89.92,104.48 89.67,104.23 PQ38.4 ; CN5.75 157.27,93.25 157.09,93.08 157.09,92.73 v1(157.33,92.5) ; v3(79.21,45.38) 78.82,45.77 U26.J2 ; v1(82.93,71.45) 82.44,70.96 U7.AD4 ; U7.G14 78.14,79.67 v1(78.21,79.67) 78.3,79.67 U7.G12 ; v1(84.85,77.82) 84.73,77.82 U7.L1 ; v1(115.24,76.88) 115.24,76.93 114.76,77.41 U20.C4 ; CN10.26 73.75,94.72 v1(73.81,94.66) ; U25.J2 61.91,45.4 v3(61.94,45.4) ; U7.BH1 U7.BH2 83.63,59.33 84.16,59.73 U7.BG1 U7.BH1 ; U7.BH1 v1(84.61,58.56) ; v1(82.34,80.2) 81.97,79.83 U7.F5 ; U7.C47 61.82,81.19 v1(61.82,80.69) 61.82,80.5 U7.E46 ; v1(80.96,79.3) 80.52,78.86 U7.H8 ; v1(70.93,97.27) 70.43,96.77 69.57,96.77 69.25,96.45 CN10.17 ; CN5.33 158.1,104.43 v1(158.07,104.46) ; CN10.13 v1(67.25,94.65) ; U16.2 98.94,80.92 v1(98.66,80.64) ; U7.AJ3 83.03,68.56 U7.AK4 ; v1(64.11,63.71) 64.12,63.71 64.15,63.68 U7.AW41 U7.AV40 ; v1(61.71,58.1) 61.72,58.21 61.76,58.51 U7.BJ47 ; U7.D10 80.26,80.12 v1(80.26,80.03) ; v1(57.84,68.57) 57.85,68.56 U7.AJ53 ; v1(84.87,73.34) 84.8,73.42 U7.W1 ; Q21.1 89.61,93.31 v1(89.08,92.78) ; v1(76.48,94.68) 76.75,94.95 CN10.32 ; v1(73.4,76.12) 73.83,75.7 U7.P22 ; v1(59.69,79.57) 59.69,80.01 U7.E51 ; v1(57.81,72.5) 57.86,72.45 57.91,72.45 57.92,72.44 U7.AA53 ; v1(88.65,102.11) 88.65,102.11 88.65,102.2 88.28,102.57 PQ38.1 ; v1(81.18,82.85) 81.15,82.82 U7.A7 ; v1(82.2,78.28) 82.2,78 82.38,77.82 U7.K4 ; v1(89.92,101.69) 89.92,101.69 89.67,101.44 PQ39.4 ; U7.BJ31 69.46,58.13 v1(69.51,58.08) ; CN10.20 70.75,94.58 v1(70.18,94.01) ; U20.N5 U20.P4 ; v1(63.59,59.97) U7.BF42 ; v1(57.97,58.7) 58.17,58.7 U7.BH53 ; CN10.38 v1(79.75,94.56) ; U7.BJ43 v1(63.63,58.08)
  BOTTOM w0.279: CN5.63 v1(156.95,96.25) ; CN5.57 157.17,97.75 v1(156.95,97.53) ; CN5.69 157.16,94.75 v1(156.95,94.96)
  BOTTOM w0.305: v3(102.73,43.42) 102.67,43.37 U27.M9 ; U26.B9 84.46,51.37 v3(84.92,51.83) ; CN18.33 v1(145.24,63.25) ; v1(148,102.47) 148,102.33 148.15,102.19 CN3.8 ; U20.E10 115.41,74.41 v1(115.24,74.23) ; U31.F9 42.79,47.99 42.79,47.99 42.54,47.74 v3(42.51,47.74) 42.89,47.37 U24.G1 ; U20.H10 117.25,73.97 v1(117.18,73.91) ; U20.F10 116.25,74.32 116.54,74.03 v1(116.54,73.9) ; U20.G5 116.75,77.4 v1(116.71,77.43) ; U33.D8 96.2,49.37 96.2,49.37 ; v1(145.85,57.25) CN18.57 ; CN3.5 149.65,102.22 v1(149.84,102.41) ; v1(120.69,75.74) 120.69,75.99 120.27,76.41 U20.P6 ; U34.A9 77.64,51.79 v3(77.64,51.75) 77.86,51.53 77.9,51.49 77.9,51.48 U26.B1 ; v1(116.36,74.97) 116.29,74.91 U20.E9 ; v1(145.38,64.78) 145.35,64.75 CN18.27 ; CN18.39 144.89,61.75 v1(145.24,62.11) ; v1(120.69,77.25) 120.69,77.28 120.57,77.41 U20.P4 ; U24.E2 43.77,49.01 v3(43.37,49.41) 43.72,49.77 U31.D8 ; CN3.12 146.15,102.24 146.34,102.43 v1(146.97,102.43) ; U27.E2 96.2,49.37 ; 96.2,49.37 v3(96.18,49.37) ; U13.18 130.35,70.97 130.12,71.19 129.4,71.19 C97.2 ; v3(102.64,51.83) 102.2,51.38 U27.B9 ; U24.B1 42.96,51.37 42.68,51.37 42.19,51.85 v1(42.19,52.29) 42.32,52.42 42.71,52.42 U31.A9 ; U20.A6 113.7,76.41 113.26,75.96 v1(113.26,75.86) ; U20.J5 117.7,76.86 117.7,76.29 v1(117.73,76.27) ; v3(101.81,46.93) 101.81,46.93 102.2,47.32 U27.G9 ; CN18.45 145.42,60.25 v1(146.15,60.98) ; v3(84.84,49.29) 84.78,49.24 U34.E1 ; U33.A9 95.55,52.42 95.29,52.42 v1(95.06,52.64) 95.06,51.81 ; v1(118.76,75.28) 118.71,75.28 118.59,75.41 U20.K8 ; U24.J2 43.77,45.74 v3(44.14,45.37) ; U27.J2 v3(96.98,45.39) ; v1(129.82,76) 130.3,75.52 U13.25 ; U32.A9 v3(60.34,51.73) U25.B1 ; v1(62.6,59.98) U7.BG47 ; v1(118.7,74.62) 118.49,74.41 U20.K10 ; CN5.1 158.95,111.75 159.11,111.6 159.11,110.38 158.98,110.25 CN5.7 157.25,110.25 156.85,109.84 v1(156.85,109.64) ; 49.81,51.81 v3(49.81,51.83) ; CN18.51 145.45,58.75 v1(145.95,59.26) ; U20.E7 115.72,75.91 115.37,75.56 v1(115.22,75.56) ; CN5.45 v1(156.95,100.75)
  BOTTOM w0.33: v3(60.1,40.43) 60.36,40.17 60.74,40.17 U25.T1 ; v3(66.75,42.17) 67.15,41.77 U25.P9 ; U25.M1 60.55,43.18 60.33,42.95 v3(60.33,42.94) ; U25.G1 60.75,47.37 v3(61.14,47.77) U32.G8 ; U31.B3 47.63,51.37 47.19,51.81 v3(47.19,51.81) ; v3(49.77,48.57) 49.76,48.57 U31.E1 ; U24.G9 49.37,47.34 48.98,46.96 v3(48.97,46.96) ; U25.G9 67.43,47.08 v3(67.62,47.08) ; U25.E8 v3(65.95,49.37) ; U24.J8 48.36,45.56 48.33,45.56 v3(48.17,45.4) ; v3(67.55,39.77) U25.T9 ; v3(49.77,50.17) 49.37,49.77 U31.D1 ; U32.D8 61.15,49.37 v3(61.14,49.37) U25.E2 ; U25.J8 66.35,45.75 v3(65.95,45.36) ; U25.P1 60.93,41.58 60.93,41.58 61.13,41.38 v3(61.13,41.37) ; v3(60.34,47.77) 60.74,48.17 U32.F9 ; U25.M9 v3(67.55,42.97) ; U24.M9 v3(49.77,42.97) ; U34.F9 78.42,47.77 v3(78.42,47.77) 78.42,47.77 U34.G8 ; U24.T9 49.37,40.13 v3(48.97,39.74) ; v3(49.82,41.37) 49.42,41.77 U24.P9 ; U24.E8 48.17,49.37 v3(48.17,49.37) ; U32.D1 66.97,49.59 v3(66.75,49.37) 66.75,49.37 66.9,49.21 U32.E1
  BOTTOM w0.343: 95.42,42.99 95.39,42.96 v3(95.13,42.96) ; U27.B1 95.51,51.37 95.06,51.81
  BOTTOM w0.356: U26.E8 84.02,49.37 v3(84.02,49.37) U34.D1 ; U26.T1 78.02,40.17 77.28,40.17 v3(77.24,40.13) ; v3(82.46,51.76) 82.82,51.4 U34.B3 ; v3(42.57,39.77) 42.85,40.05 U24.T1 ; U27.P1 95.8,41.76 v3(96.2,41.37) ; v3(77.62,42.16) 77.82,41.96 77.82,41.96 U26.P1 ; v3(101,49.37) 101.19,49.17 U27.E8 ; v3(101.81,39.74) 102.2,40.13 U27.T9 ; U27.G1 95.67,47.49 95.42,47.74 v3(95.34,47.74) ; v3(42.55,42.99) 42.92,43.37 U24.M1 ; v3(97,47.77) 96.8,47.57 U33.G8 ; v3(95.14,40.37) 95.35,40.17 95.8,40.17 U27.T1 ; v3(102.62,41.39) 102.24,41.77 U27.P9 ; U26.T9 84.6,39.98 v3(84.82,39.77) ; v3(77.62,47.77) 77.62,47.77 U26.G1 ; v3(100.14,51.75) 100.21,51.75 100.45,51.51 U33.B3 ; U24.P1 v3(43.37,41.37) ; U26.P9 84.47,41.77 84.88,41.36 v3(84.88,41.27) ; v3(65.11,51.75) 65.5,51.37 U32.B3 ; v3(101.03,45.38) 101.03,45.39 101.27,45.64 U27.J8 ; v3(95.4,48.57) 95.4,48.57 95.63,48.34 U33.F9 ; U34.D8 v3(78.42,49.37) 78.42,49.37 U26.E2 ; U33.E1 102.34,48.83 102.34,48.83 102.57,48.59 v3(102.63,48.59) ; v3(102.6,50.17) 102.4,49.97 U33.D1 ; v3(84.03,45.37) 83.63,45.77 U26.J8 ; U26.M9 84.79,42.99 v3(84.82,42.99) ; U26.M1 78.02,43.35 v3(77.61,42.94) ; U31.G8 44.03,47.63 44.14,47.74 v3(44.17,47.74) ; U27.M1 95.42,42.99
  BOTTOM w0.381: D2.2 15.99,55.91 v1(16.36,55.54) 15.8,54.98 D26.2 ; R60.1 57.92,86.49 v1(57.91,86.48) ; v1(106.78,68.29) 106.78,68.04 106.67,67.92 U8.5 ; v1(14.3,61.9) 14.46,62.03 D24.2 ; C773.2 92.08,46.98 v3(92.8,47.69) ; v1(150.19,40.78) 150.03,40.78 D43.2 ; CN16.5 15.43,20.12 15.4,20.1 14.89,20.1 v1(14.85,20.14) ; v1(138.25,70.39) 138.25,70.66 137.93,70.97 U13.11 ; v1(110.33,89.39) 110.33,89.76 110.11,89.99 U5.4 ; C704.2 87.76,39.2 v1(87.19,39.77) ; U12.5 46.95,91.85 47.23,91.57 v1(47.23,91.19) ; U12.2 49.92,91.85 v1(50.22,91.55) ; U26.G9 84.82,47.77 v3(84.82,47.77) ; U26.G9 84.06,47.73 v3(84.06,47.77) ; U26.G9 84.7,47.08 v3(84.9,47.08) ; C712.2 39.97,42.38 v1(40.2,42.61) ; C726.2 49.66,54.11 v1(49.59,54.04) ; v3(56.26,41.59) 56.53,41.33 R1047.1 ; v1(54.55,53.15) 54.52,53.13 C723.1 ; U17.2 96.44,81.81 v1(96.08,82.17) ; U18.2 112.98,46.82 114.11,46.82 114.2,46.73 v1(114.25,46.73) ; v1(42.94,60.83) 43.37,60.83 PC40.2 ; v1(55.08,53.69) 54.87,53.89 C741.2 C740.2 ; v1(123.12,46.1) 122.98,46.24 122.98,47.1 PC161.1 ; v1(57.7,49.24) 57.27,49.67 C791.2 ; PC60.2 35.61,58.23 35.86,57.98 v1(36.55,57.98) ; C101.2 100.51,65.12 100.69,65.12 101.23,64.57 v1(101.42,64.57) ; v1(128.37,52.25) 127.8,52.25 PR82.2 ; 59.06,89.27 58.56,89.77 C231.1 ; D23.2 D3.2 16.24,58.47 16.79,59.02 v1(16.99,59.02) ; C3.2 150.21,103.93 150.83,104.55 v1(150.83,104.67) ; v1(21.41,54.26) PC106.2 ; C182.1 45.81,68.32 45.81,67.77 45.38,67.34 45.08,67.34 v1(45.08,67.34) ; PR102.1 PC93.1 96.15,30.07 v1(96.01,29.94) ; v1(81.46,94.55) 81.52,94.55 C700.2 ; v1(144.13,26.69) 144.08,26.74 143.39,26.74 L10.1 ; Y2.4 68.2,87.64 v1(68.2,87.04) ; R384.1 47.57,89.7 46.89,89.7 v1(46.88,89.71) 46.17,89.71 C90.2
  BOTTOM w0.457: v1(136.58,41.25) 137.47,40.36 C279.2 ; R1148.2 22.37,28.35 21.92,27.9 ; v1(132.34,41.37) 131.7,40.73 C282.2 ; R1149.2 19.57,27.05 v1(20.02,26.59) 19.57,26.14 C816.2 ; PC107.2 29.23,47.1 v1(29.63,46.71) ; C818.2 20.84,30 21.34,29.51 v1(21.34,28.9) ; C283.2 136.31,36.99 v1(136.77,36.99) ; C706.2 94.15,35.66 v1(94.15,35.66) 94.28,35.79 R1076.1 95,35.74 C769.2 ; 21.92,27.9 21.58,27.56 C438.1 ; 21.92,27.9 v1(21.92,27.9) ; R327.2 18.55,40.96 v1(19.07,40.44) ; v1(100.19,30.48) PQ11.1
  BOTTOM w0.508: PC90.2 34.61,45.79 v1(34.9,45.79) 35.15,46.04 PC85.2 ; R69.1 85.63,91.89 v1(85.45,91.71) ; C828.2 109.2,33.5 D42.2 109.47,32.62 v1(109.53,32.56) ; v1(53.9,69.31) 53.4,69.81 R93.1 ; PR239.2 v1(92.76,102.71) ; v1(106.94,40.02) 106.19,40.02 C756.2 ; R45.1 56.13,85.46 v1(56.4,85.18) ; R1125.1 25.51,59.27 v1(26.24,58.54) ; v1(136.58,88.86) PC138.1 ; v1(87.43,84.85) 87.39,84.89 R53.2 R52.2 ; v1(72.84,37.4) 73.3,36.93 C771.1 ; v1(73.34,42.61) 73.57,42.39 C764.2 ; v1(31.67,45.48) 31.27,45.89 PC97.2 PR116.2 ; v1(86.93,50.48) 86.98,50.44 88.18,50.44 C761.2 ; PC123.1 22.35,83.28 v1(22.2,83.43) ; v1(30.23,59.91) 30.36,59.77 C807.2 ; v1(31.73,91.23) 32.41,91.23 32.77,91.58 ; v1(96.99,90.99) 96.53,91.45 R1039.1 ; v1(91.85,84.06) R160.1 ; C817.2 v1(20.7,31.97) ; v1(138.84,73.39) 139.04,73.19 R1012.1 ; v1(46.83,64.66) 46.49,65 PC37.2 ; v1(131.05,41.25) 130.61,40.81 C104.2 ; C596.1 78.88,94.48 v1(78.92,94.48) ; v1(39.88,48.78) 39.81,48.85 C729.2 ; Y2.2 70.57,89.75 v1(69.7,90.62) ; v1(75.22,45.18) 75.07,45.33 R1077.1 ; C135.2 15.46,83.02 v1(15.51,83.02) 15.51,83.04 15.96,83.49 R10.1 ; v1(88.2,52.39) 88.63,52.39 89.02,52 C759.2 ; Y4.4 32.93,57.76 v1(32.94,57.75) ; v1(80.58,84.96) R1011.1 81.23,85.57 81.23,85.57 R1183.2 ; R409.2 47.63,67.42 v1(47.73,67.32) ; v1(85.62,84.8) 85.62,84.81 86.38,85.56 R54.2 ; C795.1 R1107.2 109.26,44.01 v1(109.87,44.01) ; v1(39.55,68.71) 39.55,68.86 39.23,69.17 38.61,69.17 38.19,69.6 PC141.1 ; v1(76.02,85.87) 76.08,85.93 C43.2 ; v1(19.36,22.36) 19.92,21.79 C815.2 ; v1(129.03,96.26) PC52.1 ; C803.1 31.95,68.49 v1(31.95,68.57) 31.6,68.93 C798.1 ; C19.1 70.26,36.54 v1(70.31,36.6) ; v1(37.06,41.21) 36.58,41.69 C719.1 R1041.2 ; PC172.2 54.36,95.29 v1(54.74,95.67) ; C423.1 30.74,28.37 v1(30.3,27.93) ; PC56.1 33.85,68.48 v1(33.33,69) ; v1(120.62,38.89) 121.06,38.46 PQ3.1 ; v1(41.29,47.72) 40.99,47.42 C745.2 ; v1(97.98,54.68) 97.98,55.59 C752.2 ; R103.1 52.46,67.79 v1(52.95,67.79) ; Q24.1 v1(40.18,24.37) ; v1(18.28,57.74) 18.51,57.74 18.62,57.84 C842.1 ; v1(12.96,85.28) 13.4,85.72 Q2.1 ; C776.2 105.85,46.04 v1(105.44,46.45) 106,47.02 C711.2 ; v1(101.46,82.49) 101.69,82.27 101.69,81.68 101.13,81.13 R461.2 ; PR66.1 137.53,109.46 v1(137.15,109.84) PC73.1 ; v1(154.36,102.33) 154.36,102.33 U1.2 ; v1(39.14,59.96) 39.23,60.05 PC50.1 ; v3(55.28,38.14) 55.31,38.12 C705.2 ; v1(81.26,90.92) 81.92,90.26 81.92,89.88 ; C806.2 27.99,59.46 v1(27.99,59.93) ; VC1.2 v1(13.16,83.49) ; C718.2 60.93,35.15 v1(60.9,35.12) ; v1(138.46,51.3) 138.91,50.84 R183.2 ; v1(72.21,85.49) 72.21,86.02 71.5,86.74 C139.2 ; v1(127.26,73.33) 127.34,73.24 C240.2 ; v1(41.09,36.01) 41.19,36.11 C18.1 ; C226.1 56.28,89.99 v1(55.63,89.33) ; C138.2 68.81,86.74 68.81,86.2 v1(68.99,86.02) ; C141.1 74.8,87.39 74.4,86.99 v1(74.4,86.71) ; C742.2 39.74,50.76 v1(39.88,50.61) ; C788.2 v1(75.25,47.31) ; v1(75.25,48.96) 75.13,49.08 C789.2 74.34,50.2 C271.2 ; v1(55.97,27.84) 56.39,28.26 PQ37.1 ; v1(44.76,20.54) 46.41,20.54 47.1,21.23 CN12.4 ; v1(144.39,32.8) 144.34,32.85 SW2.6 ; R51.2 89.45,85.4 v1(89.92,84.93) ; R1027.2 83.69,85.13 v1(83.97,84.85) 84.71,85.59 R55.2 ; C100.1 132.8,41.83 v1(132.34,41.37) ; C785.2 93.65,50.92 93.9,50.67 94.67,50.67 v3(94.67,50.67) ; C97.2 129.02,71.08 128.75,70.81 v1(128.45,70.81) ; Q75.1 98.56,89.49 v1(98.89,89.49) 98.89,89.02 98.29,88.42 R163.1 ; U14.4 137.54,54.86 v1(138.69,56.01) ; R44.1 56.13,87.46 v1(56.39,87.72) ; C790.2 70.21,41.71 v1(69.92,41.99) ; v1(85.03,37.66) 84.92,37.55 C787.2 ; PR115.1 33.46,54.17 v1(33.99,54.7) 34.42,54.27 PR112.1 ; C702.2 106.07,101.97 v1(106.02,102.02) ; C767.1 102.26,36.16 v1(102.13,36.04) ; PC33.1 138.78,94.29 v1(139.19,94.71) ; SW2.2 v1(143.93,29.8) ; PR242.2 v1(92.79,100.93) ; PC11.2 v1(116.04,98.56) ; PR240.2 v1(92.79,103.72) ; v1(39.8,43.38) 39.69,43.49 R1045.1 ; C12.2 87.17,38.18 v1(86.81,38.55) ; v1(26.64,67.26) 24.79,67.26 C805.1 ; v1(121.13,42.6) 120.49,42.6 PC20.1 ; v1(29.95,54.96) 29.64,55.26 29.64,55.96 Y4.2 ; v1(44.2,24.35) 44.2,24.39 43.98,24.6 Q3.1 ; C273.2 70.82,48.94 v1(69.98,48.1) ; v1(47.9,36.46) 47.94,36.49 C743.2 ; R43.1 R47.1 55.33,69.99 v1(55.9,69.99) ; C319.1 109.09,56.05 v1(109.14,56.1) ; PR241.2 v1(92.79,99.91) ; R61.2 58.5,87.6 v1(57.89,87.6) ; v1(103.81,86.53) 103.81,85.36 104.22,84.95 R439.2 ; v1(117.96,98.69) 118.01,98.69 118.57,99.25 118.59,99.25 118.99,99.65 PC14.2 118.99,100.74 118.37,101.35 PC18.2 ; v1(49.68,66.06) 50.72,66.06 R131.1 ; v1(55.88,72.05) 55.8,72.13 R18.1 ; C713.2 56.36,47.29 v3(56.36,47.22) ; C753.2 96.09,55.62 v1(96.09,54.5) ; SW2.5 138.42,32.48 138.79,32.12 v1(138.79,31.91) ; v1(35.43,64.35) 35.93,64.35 PR49.2 ; v1(92.87,55.25) 93.24,55.62 C792.2 ; v1(69.98,44.92) 70.06,44.84 C747.2 ; C765.2 106.12,42.62 v1(106.58,42.15) 106.9,41.83 C757.2 ; v1(20.91,25.61) 20.91,25.47 20.18,24.75 C419.2 C420.1 ; PC122.2 v1(22.23,84.8) ; v1(87,91.15) 86.97,91.12 C51.1 ; R581.1 55.6,74.16 v1(55.87,73.89) 55.87,73.76 R22.1 ; v1(72.24,87.52) 72.24,87.62 72.24,87.62 C140.1 ; PC155.1 127.74,109.71 127.58,109.91 v1(127.58,110.49) ; C91.2 128.19,76.13 C95.2 128.75,75.79 128.96,76 v1(129.82,76) ; v1(26.87,69.48) 26.32,68.93 R1120.1 ; R367.1 47.73,69.06 47.73,70.06 R1007.1 47.04,70.16 47.03,70.15 v1(47.02,70.15) ; C59.1 120.02,85.28 v1(120.07,85.24) ; C15.1 v1(153.26,108.04) ; R218.2 136.44,43.79 v1(136.44,44.84) ; v1(73.34,39.18) 74,39.18 C758.2 ; PC71.2 v1(116.3,53.43) ; C13.2 52.47,43.34 v3(52.3,43.17) ; v1(82.7,84.82) 82.7,85.55 R1181.2
  vias: v1(2.54,89.22) v1(3.2,49.54) v1(3.66,4.49) v1(3.66,0.98) v1(4.95,89.3) v1(5.16,68.53) v1(5.92,5.96) v1(6.4,8.22) v1(6.56,90.79) v1(6.61,51.5) v1(6.64,19.73) v1(6.65,17.8) v1(6.65,15.86) v1(7.84,68.53) v1(8.52,51.5) v1(8.59,19.73) v1(8.59,17.8) v1(8.59,15.86) v1(8.68,89.28) v1(9.55,10.48) v1(10.53,19.74) v1(10.52,17.8) v1(10.53,15.86) v1(10.62,8.07) v1(10.75,69.66) v1(11.18,25.49) v1(11.33,51.37) v1(12.29,91.18) v1(12.52,82.36) v1(12.71,95.97) v1(12.71,93.51) v1(12.78,78.1) v1(12.78,75.96) v1(12.78,73.83) v1(13.03,98.05) v1(12.98,80.2) v1(13.49,64.63) v1(13.62,51.17) v1(14.5,51.45) v1(14.7,14) v1(15.16,13.53) v1(15.76,14.3) v1(16.64,81.93) v1(16.64,80) v1(16.56,26.81) v1(16.69,78.63) v1(16.74,9.87) v1(17.22,26.81) v1(17.88,83.96) v1(17.91,80.61) v1(17.96,13.78) v1(18.14,78.7) v1(18.21,77.46) v1(18.72,59.15) v1(18.72,11.83) v1(19.61,78.27) v1(19.97,78.86) v1(20.04,62.83) v1(20.27,78.25) v1(20.65,78.86) v1(20.7,62.93) v1(20.85,79.49) v1(20.98,78.25) v1(21.54,77.54) v1(21.85,61.33) v1(22.43,82.46) v1(23.09,80.76) v1(23.22,77.26) v1(25.41,26.88) v1(25.41,25.13) v1(25.55,94.15) v1(25.66,33.09) v1(25.91,94.73) v1(26.24,94.15) v1(26.34,56.66) v1(26.26,54.7) v1(26.29,26) v1(26.71,32.07) v1(27.16,26.88) v1(27.17,25.12) v1(27.31,63.59) v1(27.31,62.32) v1(27.43,64.86) v1(27.37,32.07) v1(27.51,48.68) v1(27.99,62.98) v1(28.03,32.07) v1(28.09,53.91) v1(28.32,56.68) v1(28.7,64.86) v1(28.7,63.59) v1(28.7,62.32) v1(29.11,93.89) v1(29.44,57.72) v1(29.85,64.86) v1(29.85,63.59) v1(29.85,62.32) v1(30.2,15.53) v1(31.09,60.74) v1(31.48,50.6) v1(31.48,49.61) v1(31.98,50.1) v1(32.47,50.6) v1(32.75,59.88) v1(33.45,32.38) v1(33.61,76.6) v1(34.37,58.56) v1(35.71,78.04) v1(35.74,25.84) v1(35.74,20.82) v1(35.92,28.03) v1(36.4,25.84) v1(36.4,20.82) v1(36.86,48.38) v1(37.49,52.37) v1(37.49,51.63) v1(37.49,50.89) v1(37.49,48.05) v1(39.75,66.13) v1(39.75,65.32) v1(39.75,64.56) v1(40.77,66.13) v1(40.77,65.32) v1(40.77,64.56) v1(41.27,15.53) v1(41.53,66.13) v1(41.66,65.32) v1(41.66,64.56) v1(42.22,73.02) v1(43.66,26.53) v1(44.49,25.9) v1(45.15,25.9) v1(45.29,25.11) v1(45.91,53.28) v1(46.1,73.93) v1(46.18,15.53) v1(46.48,73.4) v1(47.12,85.21) v1(47.12,84.45) v1(47.7,85.49) v1(47.7,84.73) v1(47.71,83.92) v1(47.71,83.2) v1(47.7,26.05) v1(48.06,17.19) v1(48.72,17.19) v1(49.68,17.16) v1(50.17,84.85) v1(50.7,51.77) v1(50.69,50) v1(50.74,39.69) v1(51.25,60.01) v1(52.03,64.56) v1(52.03,60.01) v1(52.3,102.69) v1(53.1,63.16) v1(53.35,51.5) v1(53.46,61.58) v1(53.46,58.54) v1(53.72,84.98) v1(54.18,64.57) v1(54.17,60.01) v1(55.45,102.69) v1(55.8,98.87) v1(55.75,79.26) v1(56.24,54.71) v1(56.31,99.33) v1(56.69,82.51) v1(56.9,81.09) v1(57.51,85.03) v1(57.99,64.67) v1(58.01,22.29) v1(58.1,54.17) v1(58.29,82.95) v1(58.59,50.97) v1(59,51.47) v1(59.2,45.02) v1(59.31,19.09) v1(59.31,18.33) v1(59.28,17.62) v1(59.58,103.58) v1(59.6,49.32) v1(59.58,47.79) v1(59.87,84.95) v1(59.87,64.67) v1(59.87,62.69) v1(60.07,88.64) v1(60.2,86.88) v1(60.57,89.29) v1(60.83,93.49) v1(60.76,88.66) v1(60.86,92.67) v1(60.86,91.89) v1(60.88,34.33) v1(61.13,15.53) v1(61.29,72.46) v1(61.57,89.55) v1(61.7,85.97) v1(62,83.99) v1(62,64.67) v1(62,62.69) v1(62.59,92.95) v1(62.6,61.4) v1(63.31,29.32) v1(63.43,76.33) v1(63.37,71.44) v1(63.64,106.56) v1(63.7,93.36) v1(63.97,29.32) v1(64.14,67.57) v1(64.49,15.38) v1(64.58,61.39) v1(64.63,29.32) v1(64.95,83.46) v1(65.1,89.12) v1(65.1,88.46) v1(65.29,29.32) v1(65.57,81.03) v1(65.57,62.1) v1(66.56,81.03) v1(66.73,82.85) v1(66.9,89.21) v1(66.9,83.48) v1(67.32,106.56) v1(67.27,71.28) v1(67.45,58.14) v1(67.99,66.61) v1(68.2,90.85) v1(68.43,15.41) v1(68.48,84.01) v1(68.47,78.19) v1(68.47,62.81) v1(69.44,80.28) v1(69.44,77.4) v1(69.41,53.15) v1(69.47,81.03) v1(69.46,65.66) v1(69.46,59.97) v1(70.45,62.1) v1(70.68,82.77) v1(71.58,97.25) v1(71.76,72.08) v1(71.76,66.59) v1(72.14,92.24) v1(72.11,29.32) v1(72.23,106.56) v1(72.35,79.61) v1(72.51,74.42) v1(72.54,69.72) v1(72.54,68.15) v1(72.77,99.38) v1(72.77,29.32) v1(73.35,78.18) v1(73.34,59.97) v1(73.43,29.32) v1(73.71,15.41) v1(74.1,29.32) v1(74.19,92.17) v1(74.93,99.36) v1(74.96,96.92) v1(75.29,58.11) v1(75.57,71.28) v1(76.01,48.96) v1(76.24,78.9) v1(76.33,68.16) v1(76.33,65.79) v1(76.4,83.71) v1(76.9,53.51) v1(77.04,96.99) v1(77.14,106.56) v1(77.17,99.41) v1(77.23,62.1) v1(77.23,59.97) v1(78.22,61.43) v1(78.55,53.83) v1(78.69,68.6) v1(78.66,67.57) v1(78.68,63.74) v1(78.87,15.38) v1(79.21,59.97) v1(80.02,46.17) v1(80.09,72.43) v1(80.2,61.4) v1(80.57,92.19) v1(80.8,75.34) v1(80.8,65.66) v1(80.8,64.67) v1(80.8,62.69) v1(80.87,92.9) v1(80.93,90.31) v1(81.04,54.04) v1(81.23,92.19) v1(81.2,15.41) v1(82.02,60.38) v1(82.05,106.56) v1(82.22,73.43) v1(82.93,64.67) v1(82.93,62.69) v1(83.24,102.17) v1(83.63,57.34) v1(83.69,102.66) v1(83.87,82.7) v1(84.44,83) v1(84.79,66.61) v1(85.92,47.94) v1(85.88,15.38) v1(86.13,107.5) v1(86.34,110.96) v1(86.37,114.85) v1(86.8,66.87) v1(86.87,58.09) v1(87.44,75.26) v1(88.57,65.19) v1(88.84,56.2) v1(88.99,66.87) v1(89.22,54.29) v1(89.26,26.74) v1(89.26,26.08) v1(89.71,15.41) v1(89.9,59.63) v1(90.61,61.2) v1(90.68,75.02) v1(90.77,65.19) v1(92.04,59.63) v1(92.65,57.52) v1(93.42,15.43) v1(93.52,74.49) v1(93.73,89.42) v1(94.37,89.42) v1(94.43,41.34) v1(94.57,45.23) v1(95.02,88.69) v1(95.62,75.87) v1(97.33,15.38) v1(97.44,58.16) v1(97.99,112.23) v1(98.81,100.04) v1(98.76,60.42) v1(98.88,115.16) v1(99.39,112.08) v1(100.01,53.79) v1(100.18,15.38) v1(100.71,76.8) v1(101.13,113) v1(101.93,76.27) v1(102.51,15.55) v1(102.59,76.27) v1(102.78,53.28) v1(104.57,68.14) v1(104.99,91.56) v1(105.03,30.95) v1(105.54,68.47) v1(105.77,30.95) v1(106.06,113) v1(106.15,30.37) v1(106.83,28.39) v1(107.32,48.68) v1(107.34,28.84) v1(108.45,23.9) v1(108.92,25.11) v1(109.51,37.34) v1(109.51,36.68) v1(109.51,36.02) v1(110.59,111.52) v1(110.97,113) v1(111.3,78.17) v1(112.01,111.26) v1(112.67,111.26) v1(112.82,102.68) v1(113.35,111.26) v1(113.77,101.74) v1(113.82,43.86) v1(114.53,44.62) v1(114.53,35.23) v1(114.7,102.67) v1(115.13,90.83) v1(115.19,42.76) v1(116.08,114.19) v1(116.28,44.52) v1(116.31,43.85) v1(116.59,80.36) v1(116.79,101.26) v1(117.11,90.66) v1(117.48,77.44) v1(121.47,114.94) v1(121.65,88.27) v1(121.84,53.76) v1(121.84,52.67) v1(121.84,51.58) v1(122.45,34.68) v1(122.45,33.77) v1(122.94,53.76) v1(122.94,52.67) v1(122.94,51.58) v1(122.91,34.23) v1(122.91,33.31) v1(123.6,41.73) v1(123.83,21.31) v1(124.03,53.76) v1(124.03,52.67) v1(124.03,51.58) v1(126.25,38.44) v1(126.38,114.94) v1(126.72,37.53) v1(127.2,113.71) v1(127.2,113.05) v1(127.86,113.71) v1(127.86,113.05) v1(128.35,60.47) v1(129.13,113.58) v1(130.18,36.51) v1(130.61,37) v1(133.21,114.98) v1(136.08,113.54) v1(136.12,98.29) v1(136.35,58.84) v1(136.37,98.19) v1(136.58,103.58) v1(137.87,87.94) v1(138.14,91.09) v1(138.19,29.21) v1(138.19,28.55) v1(138.19,27.89) v1(138.28,105.22) v1(138.28,104.54) v1(138.52,87.92) v1(139.35,68.52) v1(139.99,68.51) v1(140.28,77.54) v1(140.51,68.12) v1(140.75,77.1) v1(140.99,113.54) v1(141.02,69.86) v1(141.35,54.17) v1(141.35,53.51) v1(141.35,52.85) v1(141.46,69.39) v1(143.03,87.14) v1(143.45,79.87) v1(143.64,83.68) v1(143.93,36.4) v1(144.26,81.55) v1(144.59,76.23) v1(144.81,28.54) v1(145.4,76.01) v1(145.51,74.72) v1(145.64,44) v1(145.82,97.56) v1(146.12,71.34) v1(146.12,69.22) v1(146.23,98.07) v1(146.28,47.09) v1(146.39,47.73) v1(146.5,97.48) v1(146.91,62.79) v1(146.93,48.15) v1(146.89,47.32) v1(146.91,45.94) v1(146.9,45.25) v1(146.89,44.51) v1(147.98,68.47) v1(149.13,106.24) v1(149.15,19.35) v1(149.3,45.89) v1(149.65,48.17) v1(149.79,106.24) v1(150.11,87.39) v1(150.11,83.71) v1(150.11,80.03) v1(150.12,29.33) v1(150.19,50.82) v1(150.19,50.16) v1(150.19,49.49) v1(150.45,106.24) v1(150.62,90.41) v1(150.85,78.27) v1(151.61,19.35) v1(151.73,75.19) v1(152.07,50.26) v1(152.53,61.51) v1(152.63,67.43) v1(152.74,74.08) v1(153.26,77.83) v1(153.39,99.61) v1(153.79,91.07) v1(153.87,109.74) v1(154.46,27.89) v1(154.46,25.44) v1(154.47,22.98) v1(154.47,20.53) v1(154.71,67.86) v1(154.71,67.2) v1(154.71,66.54) v1(154.71,62.38) v1(154.71,61.72) v1(154.71,61.06) v1(154.71,59.22) v1(154.71,58.56) v1(156.29,103.85) v1(156.57,54.2) v1(156.72,50.65) v1(156.71,40.87) v1(156.7,37.62) v1(156.79,77.77) v1(156.79,74.93) v1(157.49,91.07) v2(25.66,52.85) v2(25.66,52.09) v2(26.43,52.09) v2(26.72,52.8) v2(27.13,51.5) v2(27.32,52.27) v2(29.35,32.81) v2(29.52,76.7) v2(29.48,75.95) v2(29.97,77.69) v2(30.02,75.43) v2(30.1,32.81) v2(30.18,76.22) v2(30.48,76.93) v2(30.85,32.81) v2(30.99,77.69) v2(30.99,76.16) v2(31.37,76.93) v2(31.69,32.4) v2(31.75,76.16) v2(31.88,77.69) v2(32.26,76.93) v2(32.77,77.69) v2(34.33,43.04) v2(34.34,42.26) v2(34.34,41.47) v2(34.34,40.71) v2(34.34,39.94) v2(37.44,77.92) v2(37.97,78.55) v2(75.3,22.46) v2(75.32,21.59) v2(75.32,20.83) v2(76.06,22.46) v2(76.08,21.59) v2(76.08,20.83) v2(76.91,22.47) v2(76.94,21.61) v2(76.94,20.84) v2(95.05,26.1) v2(95.59,26.64) v2(95.59,25.56) v2(96.13,26.1) v2(96.06,24.98) v2(96.6,25.52) v2(98.32,100.78) v2(98.43,103.55) v2(98.4,102.58) v2(98.38,101.62) v2(99.59,100.12) v2(100.36,99.89) v2(102.59,101.06) v2(103.2,101.51) v2(105.69,91.56) v2(106.44,91.56) v2(107.19,91.56) v2(107.94,91.56) v2(108.69,91.56) v2(109.44,91.56) v2(110.19,91.56) v2(111.92,58.69) v2(111.93,57.92) v2(115.8,58.66) v2(115.8,57.9) v2(116.59,59.43) v2(116.59,58.66) v2(116.59,57.9) v2(119.64,101.29) v2(119.89,106.77) v2(119.97,105.02) v2(119.99,100.07) v2(120.5,99.48) v2(121.36,91.88) v2(121.36,91.13) v2(121.36,90.38) v2(121.36,89.63) v2(122.11,91.88) v2(122.11,91.13) v2(122.11,90.38) v2(122.11,89.63) v2(127.98,59.22) v2(128.03,58.47) v2(128.02,57.73) v2(128.75,59.22) v2(128.79,58.47) v2(128.79,57.73) v2(129.54,57.72) v2(129.57,59.22) v2(129.57,58.47) v2(130.32,59.22) v2(130.33,58.47) v2(130.35,57.72) v2(131.54,59.29) v2(131.51,58.49) v2(131.51,57.73) v2(133.01,59.29) v2(133.03,58.52) v2(133.04,57.74) v2(133.79,59.28) v2(133.79,58.53) v2(133.79,57.78) v2(134.54,58.54) v2(134.56,59.29) v2(134.57,57.79) v2(135.36,96.97) v2(136.81,99) v2(137.06,99.74) v2(137.31,100.47) v2(137.26,98.31) v2(137.57,99.13) v2(137.82,99.84) v2(138.02,98.52) v2(138.1,100.55) v2(138.35,99.2) v2(138.58,99.94) v2(139.73,102.02) v2(140.54,102.01) v2(144.01,104.13) v3(45,39.36) v3(45.06,42.33) v3(45.21,41.58) v3(45.2,38.27) v3(45.17,37.3) v3(45.3,43.27) v3(46.47,49.55) v3(47.21,42.2) v3(52.59,38.72) v3(54.72,43.16) v3(63.11,49.54) v3(64.82,43.59) v3(64.81,40.83) v3(64.91,39.23) v3(65.04,37.28) v3(66.18,54.16) v3(80.11,39.55) v3(80.1,36.72) v3(80.35,41.87) v3(80.25,38.27) v3(86.71,46.44) v3(89.31,40.37) v3(91.19,36.41) v3(92.4,40.65) v3(93.07,37.36) v3(94.77,49.26) v3(99.89,40.89) v3(100,39.18) v3(100.1,43.58) v3(100.09,37.28)
