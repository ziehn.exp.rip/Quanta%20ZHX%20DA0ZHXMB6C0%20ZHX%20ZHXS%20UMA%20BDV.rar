# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLLCPU_1P24_PWR: length 16.1
  TOP w0.508: R395.2 55.25,70.92 55.25,72.48 55.98,73.22 62.06,73.22 62.48,72.8 63.33,72.8 64.09,72.04 C217.1 66.08,72.04
  BOTTOM w0.305: U7.AD35 67.61,70.88 v1(67.23,70.5) 67.61,70.12 U7.AF35 ; U7.AC36 66.85,71.66 66.48,71.29 v1(66.45,71.29) 66.42,71.26 66.42,71.23 66.09,70.91 U7.AD38
PLTRST#: length 292.8
  TOP w0.102: v1(138.28,73.92) 138.5,74.14 R408.1 141.67,76.37 141.67,77.02 143.03,78.38 143.03,80.56 143.21,80.74 143.21,84.09 143.18,84.12 143.18,84.62 143.03,84.78 143.03,85.72 143.21,85.89 146.76,85.89 147.98,87.11 147.98,93.3 150.38,95.69 150.38,97.23 150.85,97.7 151.39,97.7 152.66,98.97 R302.2 ; U9.22 127.91,29.5 128.22,29.81 130.58,29.81 132.72,27.68 v1(133.61,27.68)
  IN1 w0.14: v1(19.13,54.37) 20.45,54.37 22.96,56.89 22.96,64.17 24.52,65.73 24.52,72.32 23.03,73.82 23.03,75.54 22.66,75.91 22.66,79.87 21.97,80.56 21.97,80.99 20.14,82.83 20.14,86.27 22.57,88.7 22.57,91.65 23.97,93.04 29.25,93.04 29.84,92.45 35.44,92.45 38.65,95.67 46.63,95.67 47.67,96.71 48.52,96.71 53.41,96.71 54.58,97.88 57.15,97.88 58.32,96.71 59.36,96.71 60.73,98.08 77.06,98.08 78.06,97.08 81.6,97.08 82.01,96.67 83.71,96.67 84.58,95.8 86.89,95.8 89.76,92.93 v1(89.76,92.65) 89.76,92.5 93.3,88.96 94,88.96 95.19,87.77 96.79,87.77 99.01,85.55 100.6,85.55 101.47,84.69 102.16,84.69 102.79,84.06 109.02,84.06 109.86,83.23 113.49,83.23 115.58,81.14 120.01,81.14 121.42,79.74 126.23,79.74 127.51,78.45 130.53,78.45 131.24,77.74 133.81,77.74 134.04,77.98 134.4,77.98 134.53,77.85 134.53,77.84 134.97,77.4 v1(135.44,77.4) 135.44,77.73 135.78,78.07 136.14,78.07 137.1,77.11 137.1,75.1 v1(138.28,73.92) 138.28,73.29 138.59,72.98 138.62,72.98 141.97,69.63 141.97,65.12 143.53,63.56 143.53,58.5 143.96,58.07 143.96,50.34 141.49,47.87 141.49,47 140.25,45.76 140.25,42.67 139.61,42.04 139.61,41.06 138.82,40.26 138.82,37.73 136.88,35.79 136.88,34.02 135.85,33 135.85,30.1 133.61,27.85 v1(133.61,27.68)
  BOTTOM w0.102: R1124.1 23.75,56 22.63,54.88 19.59,54.88 19.13,54.42 v1(19.13,54.37) ; v1(135.44,77.4) 135.7,77.14 135.7,76.5 135.5,76.3 135.28,76.3 134.09,75.12 134.09,74.16 133.18,73.25 133.18,71.06 131.79,69.67 U13.16 ; v1(89.76,92.65) 90.24,92.18 R416.1 90.44,92.19 Q39.3
PLTRST#_2: length 6.6
  TOP w0.108: CN5.52 158.12,99 157.43,99.69 156.74,99.69 156.39,100.04 R297.1 155.55,99.5 154.74,99.5 R302.1
PMU_BATLOW#: length 8.3
  BOTTOM w0.102: U7.C14 77.72,81.51 77.39,81.83 77.39,82.03 77.51,82.15 77.51,82.43 78.06,82.97 78.06,83.73 78.23,83.9 78.23,84.8 77.73,85.31 77.73,86.32 77.34,86.71 77.34,87.49
  BOTTOM w0.108: R57.2 77.34,88.01 77.34,87.49
PMU_RSMRST#: length 62.6
  TOP w0.127: v1(125.77,78.33) 125.77,79.22 122.58,82.41 122.58,92.08 121.11,93.55 121.11,94.52 118.44,97.19 118.44,99.2 118.65,99.41 PR2.1
  IN2 w0.127: v1(93.55,87.57) 94.34,86.78 95.09,86.78 95.62,86.25 96.25,86.25 97.93,84.57 99.05,84.57 99.61,84.01 100.36,84.01 100.63,83.73 101.43,83.73 101.95,83.21 102.78,83.21 103.28,82.71 104.37,82.71 104.87,83.21 114.22,83.21 115.52,81.91 116.81,81.91 117.46,81.26 119.27,81.26 120.13,80.4 120.7,80.4 122.58,78.52 125.58,78.52 v1(125.77,78.33)
  BOTTOM w0.127: R177.1 93.37,86.92 93.37,87.4 v1(93.55,87.57)
PMU_WIFI_SUSCLK: length 5.3
  BOTTOM w0.102: 77.19,83.58 76.66,83.05 76.66,82.44 77.06,82.03 77.06,81.74 U7.C15
  BOTTOM w0.108: TP1.1 77.39,85.87 77.39,83.78 77.19,83.58
PROCHOT_EC: length 16.1
  TOP w0.108: v1(131.86,37.09) 131.46,37.09 131.17,36.79 131.17,35.43 128.65,32.91 128.65,32.48 128.91,32.22 128.91,31.59 128.75,31.43 127.53,31.43 127.46,31.5 U9.17
  BOTTOM w0.108: v1(131.86,37.09) 131.53,37.09 R250.2 131.24,37.26 130.78,37.72 130.52,37.72 129.34,38.9 128.91,38.9 128.6,38.6 v1(128.12,38.6) 128.09,38.6 127.71,38.98 Q40.2
PSELF: length 5.3
  BOTTOM w0.108: U35.22 27.08,66.69 27.33,66.94 27.33,67.47 27.12,67.68 25.63,67.68 25.02,68.29 v1(25.02,68.8) R1119.1
R_SPK+: length 24.4
  IN2 w0.889: 29.9,21.15 28.12,19.37 25.07,19.37 24.82,19.62 21.11,19.62 20.17,18.68 18.67,18.68 16.64,16.65 16.64,13.68 15.57,12.61 11.01,12.61
  vias: v1(10.07,13.16) v1(10.07,12.5) v1(30.3,21.91) v1(30.95,21.91)
R_SPK+_1:
  vias: v1(33.96,20.82) v1(34.62,20.82)
R_SPK-: length 28.2
  IN2 w0.889: 32.18,21.81 32.18,20.97 31.78,20.56 30.94,20.56 28.58,18.2 24.31,18.2 24.03,18.48 21.62,18.48 20.68,17.54 19.43,17.54 17.78,15.89 17.78,13.2 16.03,11.45 15.8,11.45 15.77,11.47 10.59,11.47
  vias: v1(9.41,13.16) v1(9.41,12.5) v1(31.67,22.64) v1(32.34,22.64)
R_SPK-_1:
  vias: v1(33.96,22.62) v1(34.62,22.62)
RAM_ID0: length 8
  BOTTOM w0.102: U7.C11 79.72,81.57 79.95,81.8 79.95,82.08 79.91,82.13 79.91,82.45 80.09,82.64 80.09,83.19 80.49,83.59 80.49,83.77 81.3,84.59 81.6,84.59 82.27,85.25 82.27,85.92 R1181.1 82.69,87.02 R1180.2
RAM_ID1: length 6.9
  BOTTOM w0.102: U7.B10 79.7,81.97 79.7,82.54 79.89,82.72 79.89,83.28 80.28,83.68 80.28,83.86 81.26,84.83 81.56,84.83 82.06,85.34 82.06,85.93 R1183.1 81.64,87.06 R1182.2
RAM_ID2: length 21.6
  TOP w0.108: R1184.2 95.31,77.21 v1(95.12,77.03) 94.71,76.61 94.71,76.12 95.01,75.82 R1185.1 94.76,75.72 94.24,76.24 94.24,76.29 v1(94.18,76.34)
  IN1 w0.102: 83.57,78.91 83.39,78.91 83.21,79.09 81.69,79.09 81.28,78.68 80.27,78.68 79.76,79.19 79.76,79.62 v1(79.2,80.18)
  IN1 w0.14: 83.57,78.91 87.5,78.91 88.7,77.72 92.4,77.72 93.04,77.07 93.89,77.07 94.18,76.77 v1(94.18,76.34)
  BOTTOM w0.102: U7.F12 78.99,79.96 v1(79.2,80.18)
RAM_ID3: length 21.9
  TOP w0.108: R1186.2 94.22,77.44 94.01,77.23 93.42,77.23 92.96,76.77 92.96,76.53 92.69,76.26 92.69,76.01 93.04,75.66 93.8,75.66 93.87,75.72 R1187.1 94.06,75.85 93.63,76.29 93.63,76.55 93.59,76.58 v1(93.59,76.6)
  IN1 w0.102: 83.57,78.63 83.24,78.63 83.11,78.76 81.69,78.76 81.41,78.48 80.18,78.48 79.21,79.45 v1(79.2,79.45)
  IN1 w0.14: 83.57,78.63 87.38,78.63 88.57,77.44 92.28,77.44 93.02,76.7 93.47,76.7 93.57,76.6 v1(93.59,76.6)
  BOTTOM w0.102: U7.F10 v1(79.2,79.45)
RESET#_USB: length 5.9
  BOTTOM w0.108: U35.17 24.66,63.09 R1123.1 C808.2 v1(24.27,60.93) 23.75,60.42 R1124.2 R1125.2
RF_EN: length 91.1
  TOP w0.108: v1(151.69,95.8) 152.2,96.31 153.68,96.31 C595.2 154.3,96.87 R999.2 ; v1(147.39,24.92) v1(146.13,24.92) 144.29,24.92 143.32,25.9 U9.66
  IN1 w0.14: v1(147.39,24.92) 147.39,25.69 149.52,27.82 149.52,34.21 149.87,34.56 149.87,35.08 153.76,38.97 153.76,39.55 155.46,41.25 155.46,74.33 152.91,76.88 149.66,76.88 148.9,77.64 148.9,79.47 148.03,80.33 148.03,82.1 148.5,82.57 148.5,93.44 150.87,95.8 v1(151.69,95.8)
RF_EN_R: length 3.8
  TOP w0.108: R999.1 156.21,98 v1(158.14,98) CN5.56
RING2:
  vias: v1(6.15,28.31) v1(6.81,28.31) v1(9.68,21.83) v1(10.34,21.83)
RING2_R:
  vias: v1(7.62,37.33)
RREF: length 2.8
  BOTTOM w0.108: U23.1 25.04,28.7 24.82,28.92 v1(24.05,28.92) 23.66,28.92 R1148.1
RSMRST#: length 107.3
  TOP w0.102: v1(136.4,35.4) 136.4,35.64 134.7,37.34 U9.112
  IN1 w0.14: v1(136.4,35.4) 136.4,35.91 137.39,36.9 137.39,38.65 138.42,39.68 138.42,42.73 139.92,44.23 139.92,45.89 141.17,47.13 141.17,48 143.64,50.47 143.64,57.94 143.21,58.36 143.21,63.38 141.65,64.94 141.65,68.54 137.75,72.44 137.75,73.41 136.86,74.3 136.86,74.7 136.57,74.98 136.57,76.08 136.3,76.35 135.78,76.35 135.71,76.28 135.25,76.28 134.91,75.94 133.97,75.94 132.64,77.28 v1(132.11,77.28)
  IN2 w0.14: v1(132.11,77.28) 130.38,75.54 128.39,75.54 128.18,75.75 125.67,75.75 125.09,76.33 123.66,76.33 123.26,75.93 122.29,75.93 121.61,75.24 120.53,75.24 120.14,75.63 120.14,77.6 119.06,78.69 118.1,78.69 118,78.78 115.42,78.78 113.73,80.47 109.52,80.47 108.18,79.14 108.18,78.75 107.86,78.43 102.97,78.43 102.34,79.06 100.92,79.06 100.54,79.43 99.8,79.43 99.09,80.15 98.41,80.15 96.85,81.71 95.88,81.71 95.19,82.4 94.31,82.4 93.39,83.32 93.39,83.75 92.87,84.26 v1(92.55,84.26)
  BOTTOM w0.102: R166.1 92.55,85.67 v1(92.55,84.26)
RSVD_K20: length 0.6
  BOTTOM w0.102: v1(74.35,78.12) 74.64,77.83 U7.K20
RSVD_M13: length 2.2
  TOP w0.108: R349.1 80.06,77.9 v1(79.42,77.26)
  BOTTOM w0.102: v1(79.42,77.26) 78.74,77.26 U7.M13
RSVD_M20: length 0.5
  BOTTOM w0.102: v1(74.42,76.77) 74.77,77.12 U7.M20
RTC_3P3A_PWR: length 9.6
  TOP w0.508: R303.2 R309.2 84.83,86.09 84.83,84.18 85.06,83.94 85.06,82.64 84.19,81.77 C168.1 84,81.77 C170.1 83.59,80.77 83.41,80.6 v1(83.08,80.6)
  BOTTOM w0.254: U7.E3 83.08,80.12 v1(83.08,80.6) 83.02,80.66 U7.D4
RTC_X1: length 15.7
  IN2 w0.102: 73.03,81.35 73.03,79.81 74.24,78.59 75.07,78.59 76.19,77.47 v1(76.24,77.47)
  IN2 w0.14: v1(73.13,85.23) 73.23,85.23 73.74,84.72 73.74,82.54 73.03,81.83 73.03,81.35
  BOTTOM w0.102: Y3.1 72.44,88.9 73.02,88.33 C140.2 73.02,87.09 R304.1 73.13,86.72 v1(73.13,85.23) ; v1(76.24,77.47) U7.M18
RTC_X2: length 15.1
  IN2 w0.102: v1(76.24,78.19) 76.16,78.19 74.8,79.54 73.93,79.54 73.38,80.09 73.38,81.35
  IN2 w0.14: v1(73.92,85.31) 74.27,84.96 74.27,82.36 73.38,81.47 73.38,81.35
  BOTTOM w0.102: v1(73.92,85.31) 73.66,85.57 73.66,86.95 R304.2 73.67,87.79 C141.2 74.02,88.33 74.94,89.25 Y3.2 ; v1(76.24,78.19) U7.K18
S5_ON: length 196.1
  TOP w0.127: v1(144.78,31.09) 145.14,30.73 R244.2 ; PQ24.2 113.46,37.58 113.82,37.22 113.82,36.56 114.01,36.37 115.2,36.37 v1(115.74,35.83) ; v1(128.48,95.74) 127.48,94.74 125.19,94.74 124.67,94.21 124.67,85.07 124.99,84.74 124.99,82.44 128.84,78.59 128.84,75.83 129.77,74.89 v1(129.77,73.33)
  TOP w0.254: v1(137.15,110.8) 136.85,110.8 135.46,109.41 135.46,108.55 136.27,107.74 136.27,105.28 135.13,104.14 134.76,104.14 132.98,102.36 132.98,101.46 132.64,101.12 130.81,101.12 129,99.31 129,98.02 128.48,97.5 v1(128.48,95.74) 128.86,95.36 PR169.1 ; v1(103.89,101.97) 103.28,102.58 100.79,102.58 PQ35.2
  IN1 w0.254: v1(128.48,95.74) 127.72,94.98 121.88,94.98 121.49,94.58 119.41,94.58 117.6,92.78 116.71,92.78 115.67,93.82 101.5,93.82 101.12,94.2 101.12,99.3 102.29,100.47 103.2,100.47 103.89,101.16 v1(103.89,101.97)
  IN2 w0.127: v1(144.78,31.09) 145.09,31.39 145.09,32.91 143.26,34.74 139.47,34.74 138.77,34.03 132.1,34.03 131.69,34.44 128.41,34.44 128.07,34.1 125.51,34.1 123.28,36.33 123.27,36.33 v1(122.24,37.36) 119.65,34.78 116.79,34.78 v1(115.74,35.83) 115.84,35.94 115.84,40.03 117.32,41.52 117.32,45.92 117.05,46.19 117.05,49.43 117.18,49.55 117.18,51.15 117.5,51.48 117.5,52.26 116.93,52.84 116.25,52.84 115.84,53.24 115.84,57 114.76,58.08 114.76,61.13 113.47,62.41 113.47,63.49 116.32,66.34 124.78,66.34 125.49,67.04 130.08,67.04 131.42,68.37 132.49,68.37 132.74,68.62 132.74,69.58 129.78,72.54 129.78,73.33 v1(129.77,73.33)
  BOTTOM w0.127: v1(122.24,37.36) 123.72,37.36 123.96,37.6 PQ3.2
  BOTTOM w0.254: PR80.2 v1(137.15,110.8) ; PR7.2 v1(103.89,101.97)
S5_ON_R: length 27.9
  TOP w0.108: R1196.2 139.07,57.59 141.78,57.59 142.55,56.82 142.55,54.56 v1(143.8,53.31) 144.45,52.65 v1(145.68,52.65) ; v1(141.79,45.13) 141.5,45.42 R440.2 141.12,45.05 141.12,42.87 140.74,42.48 140.56,42.48 139.94,41.87 139.94,40.86 139.5,40.42 U9.100
  IN1 w0.14: v1(145.68,52.65) 145.33,52.3 145.33,49.79 142.87,47.33 142.87,46.2 v1(141.79,45.13)
S5D: length 21.4
  TOP w0.254: PQ17.4 109.36,108.66 109.19,108.49 108.16,108.49 107.86,108.79 107.86,108.79 PC163.2 106.75,108.12 v1(105.94,108.12) 105.67,108.39 PR218.2 105.67,109.58 105.66,109.59 v1(105.66,109.97) ; PQ34.3 99.35,104.61 98.49,105.47 PR201.2 98.36,104.77 v1(98.45,104.77)
  IN1 w0.254: v1(105.66,109.97) 105.1,109.41 101.95,109.41 101.13,108.59 101.13,105.8 100.1,104.77 v1(98.45,104.77)
SATA_GP0: length 7.1
  BOTTOM w0.102: 86.72,70.03 86.72,70.03 85.98,69.29 84.7,69.29 84.46,69.04 U7.AH2
  BOTTOM w0.108: 86.72,70.03 87.01,70.03 87.15,69.89 87.4,69.89 87.53,70.02 88.76,70.02 R181.1
SATA_GP1: length 13
  BOTTOM w0.102: U7.AG3 83.66,69.33 83.97,69.33 84.05,69.25 84.37,69.25 84.56,69.43 84.62,69.49 85.78,69.49 86.64,70.36 86.72,70.36
  BOTTOM w0.108: R1018.1 92.43,66.67 92.43,67.12 91.64,67.91 91.64,68.72 90.99,69.38 89.71,69.38 88.73,70.36 86.72,70.36
SATA_LED#: length 8.1
  TOP w0.108: R170.2 88.98,70.24 87.29,70.24 85.58,68.53 v1(85.49,68.53)
  BOTTOM w0.089: v1(85.49,68.53) 85.47,68.54
  BOTTOM w0.102: 85.42,68.6 85.06,68.96 84.66,68.96 84.54,68.84 84.04,68.84 83.95,68.75 83.71,68.75 83.48,68.98 ; 83.47,68.99 83.42,69.04 U7.AH3
  BOTTOM w0.108: 85.47,68.54 85.42,68.6 ; 83.48,68.98 83.47,68.99
SATA_RCOMP_DN: length 2.7
  TOP w0.102: v1(69.52,76.75) 69.72,76.75 69.85,76.88 69.85,78.14 69.77,78.22 69.6,78.22 R355.2
  BOTTOM w0.102: v1(69.52,76.75) 69.58,76.75 U7.M30
SATA_RCOMP_DP: length 3.8
  TOP w0.102: R355.1 70.05,78.23 70.05,76.65 v1(69.5,76.09)
  BOTTOM w0.102: U7.N30 69.81,76.41 v1(69.5,76.09)
SATA_RXN0: length 105.1
  TOP w0.102: v1(144.63,76.87) 144.82,77.06 144.82,77.05 145.37,77.05 C831.2
  IN2 w0.102: v1(70.49,77.49) 70.97,77.97 70.97,80.6 70.77,80.8 70.77,81.3 70.74,81.33 70.74,81.35
  IN2 w0.14: 70.74,81.35 70.74,81.88 71.15,82.28 71.15,82.96 70.94,83.16 70.94,85.26 71.93,86.25 72.85,86.25 74.12,87.52 75.92,87.52 78.06,89.65 80.93,89.65 82.54,91.27 83.74,91.27 84.93,92.46 85.94,92.46 87.25,93.77 89.7,93.77 92.44,91.02 95.19,91.02 99.02,87.19 100.13,87.19 100.7,86.63 101.44,86.63 101.72,86.35 102.52,86.35 103.01,85.86 109.12,85.86 109.77,86.51 116.56,86.51 119.08,83.99 120.84,83.99 123.69,81.14 127.72,81.14 128.32,80.55 131.74,80.55 132.84,81.64 139.96,81.64 142.89,84.58 143.78,84.58 144.99,83.36 144.99,79.51 145.47,79.04 145.47,77.23 145.19,76.95 144.71,76.95 v1(144.63,76.87)
  BOTTOM w0.102: C119.2 145.84,77.05 144.81,77.05 v1(144.63,76.87) ; U7.M28 70.85,77.12 v1(70.49,77.49)
SATA_RXN0_NGFF: length 25.4
  TOP w0.102: v1(151.11,74.87) 150.85,75.12 149.55,75.12 147.52,77.16 146.63,77.16 C831.1
  IN2 w0.14: v1(151.11,74.87) 150.9,75.07 150.72,75.07 150.58,74.94 150.58,66.1 148.06,63.57 148.06,62.02 147.6,61.56 147.15,61.56 v1(146.91,61.32)
  BOTTOM w0.102: v1(146.91,61.32) 146.7,61.52 145.81,61.52 145.19,60.91 144.94,60.91 144.78,60.75 CN18.43
SATA_RXN0_R: length 36.9
  BOTTOM w0.102: C119.1 147.33,77.05 148.11,77.05 148.87,76.29 152.02,76.29 154.05,74.26 154.05,48.45 154.97,47.54 155.67,47.54 CN9.5
SATA_RXP0: length 105.1
  TOP w0.102: C832.2 145.33,77.26 144.91,77.26 v1(144.63,77.53)
  IN2 w0.102: v1(70.49,76.8) 70.94,76.8 71.07,76.93 71.07,77.1 70.92,77.26 70.92,77.63 71.17,77.88 71.17,80.69 70.97,80.88 70.97,81.29 71.01,81.32 71.01,81.35
  IN2 w0.14: v1(144.63,77.53) 144.95,77.22 145.08,77.22 145.2,77.34 145.2,78.92 144.73,79.4 144.73,83.25 143.67,84.31 143,84.31 140.07,81.38 132.95,81.38 131.85,80.28 128.21,80.28 127.61,80.88 123.58,80.88 120.73,83.72 118.96,83.72 116.45,86.24 109.88,86.24 109.23,85.59 102.9,85.59 102.41,86.09 101.61,86.09 101.33,86.36 100.59,86.36 100.02,86.93 98.91,86.93 95.08,90.76 92.33,90.76 90.47,92.61 89.59,93.5 87.36,93.5 86.05,92.19 85.04,92.19 83.85,91 82.65,91 81.04,89.39 78.17,89.39 76.03,87.25 74.23,87.25 72.96,85.98 72.04,85.98 71.21,85.15 71.21,83.27 71.41,83.07 71.41,82.17 71.01,81.77 71.01,81.35
  BOTTOM w0.102: U7.N28 70.88,76.41 v1(70.49,76.8) ; v1(144.63,77.53) 144.91,77.26 145.8,77.26 C120.2
SATA_RXP0_NGFF: length 25.5
  TOP w0.102: C832.1 146.47,77.36 147.6,77.36 149.63,75.33 150.9,75.33 v1(151.11,75.53)
  IN2 w0.14: v1(146.91,62.13) 147.21,61.83 147.49,61.83 147.79,62.13 147.79,63.68 150.32,66.21 150.32,75.05 150.65,75.38 150.95,75.38 v1(151.11,75.53)
  BOTTOM w0.102: v1(146.91,62.13) 146.51,61.73 145.72,61.73 145.11,61.11 144.95,61.11 144.81,61.25 CN18.41
SATA_RXP0_R: length 37
  BOTTOM w0.102: CN9.6 155.67,47.74 155.05,47.74 154.26,48.54 154.26,74.34 152.1,76.5 148.95,76.5 148.19,77.26 147.37,77.26 C120.1
SATA_TXN0: length 105.9
  TOP w0.102: C829.2 145.98,75.43 145.9,75.35 145.24,75.35 145.16,75.28 144.93,75.28 144.86,75.35 v1(144.86,75.62)
  IN2 w0.14: v1(144.86,75.62) 144.86,75.47 144.95,75.39 145.15,75.39 145.22,75.45 145.62,75.45 146.37,76.2 146.37,78.93 145.52,79.78 145.52,83.58 143.99,85.11 142.37,85.11 139.43,82.17 132.62,82.17 131.52,81.07 128.54,81.07 127.93,81.68 123.89,81.68 121.05,84.51 119.29,84.51 116.76,87.05 109.46,87.05 109.09,86.68 104.9,86.68 103.99,87.59 100.6,87.59 99.77,88.41 98.54,88.41 95.38,91.57 92.64,91.57 89.91,94.3 85.57,94.3 84.66,93.39 84.66,92.93 83.55,91.82 82.34,91.82 81.92,91.4 80.82,91.4 79.6,90.19 77.75,90.19 75.65,88.09 73.87,88.09 72.55,86.77 71.54,86.77 70.38,85.61 70.38,84.57 69.82,84 69.82,83.85 70,83.66 70,83.53 70.11,83.43 v1(70.31,83.43)
  BOTTOM w0.102: v1(70.31,83.43) 70.05,83.43 69.94,83.32 69.94,82.3 70,82.24 70.07,82.24 70.28,82.02 70.28,81.85 70.16,81.73 70.06,81.73 69.94,81.84 U7.B30 ; C123.2 146.19,75.42 146.13,75.35 144.93,75.35 144.86,75.42 v1(144.86,75.62)
SATA_TXN0_NGFF: length 27.8
  TOP w0.102: C829.1 146.83,75.34 148.4,75.34 149.65,74.09 151.78,74.09 v1(152.18,74.49)
  IN2 w0.14: v1(146.86,60.67) 147.17,60.35 147.9,60.35 148.29,60.75 149.56,60.75 151.19,62.38 151.19,73.74 151.68,74.22 151.91,74.22 v1(152.18,74.49)
  BOTTOM w0.102: v1(146.86,60.67) 146.57,60.39 146.05,60.39 145.41,59.75 CN18.47
SATA_TXN0_R: length 38
  BOTTOM w0.102: CN9.3 155.67,43.93 154.8,43.93 153.44,45.29 153.44,71.47 152.24,72.66 151.38,72.66 148.67,75.38 147.34,75.38 C123.1
SATA_TXP0: length 105.6
  TOP w0.102: C830.2 145.98,74.87 145.7,75.15 145.32,75.15 145.22,75.05 145.06,75.05 v1(144.86,74.85)
  IN2 w0.14: v1(69.55,83.44) 69.55,84.11 70.12,84.68 70.12,85.72 71.43,87.04 72.44,87.04 73.76,88.36 75.54,88.36 77.64,90.45 79.49,90.45 80.71,91.67 81.81,91.67 82.22,92.09 83.44,92.09 84.39,93.04 84.39,93.5 85.46,94.57 90.02,94.57 92.75,91.84 95.49,91.84 98.65,88.68 99.88,88.68 100.71,87.85 104.1,87.85 105.01,86.95 108.98,86.95 109.35,87.32 116.87,87.32 119.4,84.78 121.17,84.78 124,81.94 128.04,81.94 128.65,81.33 131.41,81.33 132.51,82.43 139.32,82.43 142.26,85.37 144.1,85.37 145.78,83.69 145.78,79.89 146.64,79.04 146.64,76.09 145.73,75.19 145.33,75.19 145.26,75.12 145.13,75.12 v1(144.86,74.85)
  BOTTOM w0.102: C122.2 145.84,75.15 145.16,75.15 v1(144.86,74.85) ; U7.C31 69.62,81.74 69.62,82.03 69.74,82.15 69.74,83.25 v1(69.55,83.44)
SATA_TXP0_NGFF: length 27.8
  TOP w0.102: v1(152.18,73.69) 151.98,73.89 149.57,73.89 148.32,75.14 146.77,75.14 C830.1
  IN2 w0.14: v1(152.18,73.69) 151.91,73.96 151.79,73.96 151.46,73.63 151.46,62.27 149.67,60.48 148.4,60.48 148.01,60.09 147.08,60.09 v1(146.86,59.86)
  BOTTOM w0.102: CN18.49 144.81,59.25 145.11,59.55 145.5,59.55 146.14,60.19 146.53,60.19 v1(146.86,59.86)
SATA_TXP0_R: length 38
  BOTTOM w0.102: C122.1 147.36,75.17 148.58,75.17 151.3,72.46 152.16,72.46 153.24,71.38 153.24,45.2 154.71,43.73 155.67,43.73 CN9.2
SB_ACDC: length 54.5
  TOP w0.127: v1(110.34,26.41) 110.26,26.48 110.26,30.13 106.03,34.36 104.2,34.36 v1(101.72,31.89) PR220.2 ; v1(138.13,31.91) 139.32,33.1 U9.84
  IN1 w0.127: v1(138.13,31.91) 137.45,31.23 137.45,27.46 136.49,26.5 132.33,26.5 131.88,26.05 129.36,26.05 128.5,26.91 123.38,26.91 123.19,26.72 117.61,26.72 116.66,25.77 111.35,25.77 110.69,26.43 110.36,26.43 v1(110.34,26.41)
SCL_TO_EC: length 4.1
  TOP w0.102: U9.94 144.7,37.1 144.91,37.3 R1153.1 R1172.1
SCL_TO_EC_R: length 50.9
  TOP w0.102: v1(146.8,37.16) 146.33,37.16 R1153.2
  TOP w0.203: v1(122.52,21.31) 122.52,21.66 122.2,21.98 R1198.2 120.48,21.3 C323.1 116.23,21.03 115.18,22.08 U21.4
  IN2 w0.14: v1(146.8,37.16) 146.8,35.45 145.5,34.15 145.5,33.53 145.85,33.18 145.85,21.56 144.79,20.5 122.94,20.5 122.52,20.92 v1(122.52,21.31)
SD_CD#: length 13.9
  BOTTOM w0.108: R392.2 18.64,21.63 18.19,22.08 18.19,22.44 18.52,22.77 20.6,22.77 21.49,21.88 22.3,21.88 22.95,21.24 v1(26.37,21.24) 26.84,21.24 27.89,22.29 27.89,23.13 27.54,23.48 U23.13
SD_CD#_R: length 17.3
  BOTTOM w0.108: CN16.1 15.97,11.12 14.94,12.16 13.43,12.16 12.21,13.37 12.21,16.38 13.8,17.96 14.73,17.96 16.11,19.34 17.72,19.34 18.84,20.46 R392.1
SD_CLK: length 23.3
  IN2 w0.14: v1(26.44,22.6) 26.44,23.7 26.32,23.83 25.71,23.83 25.58,23.7 25.58,22.95 25.45,22.82 24.94,22.82 24.81,22.95 24.81,23.84 24.68,23.97 24.42,23.97 24.29,23.84 24.29,22.95 24.16,22.82 23.72,22.82 23.59,22.95 23.59,24.65 23.47,24.78 23.09,24.78 22.97,24.65 22.97,22.95 22.84,22.82 22.54,22.82 22.41,22.95 22.41,24.86 22.28,24.98 19.39,24.98 19.27,25.11 19.27,25.94 19.39,26.07 20.6,26.07 20.73,26.2 20.73,27.05 20.19,27.6 v1(20.19,28.02)
  BOTTOM w0.102: v1(26.44,22.6) 26.54,22.69 U23.15 ; R394.1 20.17,28.03 v1(20.19,28.02)
SD_CLK_R: length 4.5
  BOTTOM w0.102: CN16.7 18.26,25.12 v1(18.53,25.39) 18.79,25.65 C816.1 R1149.1 R394.2
SD_CMD: length 21.2
  TOP w0.102: R1145.2 17.81,25.02 17.96,25.17 18.38,25.17 18.48,25.07 18.48,23.45 18.68,23.26 v1(19.13,23.26) 19.24,23.37 19.24,24.98 19.36,25.11 19.58,25.11 19.71,24.98 19.71,23.13 19.84,23.01 20.18,23.01 20.3,23.13 20.3,25.03 20.43,25.16 20.63,25.16 20.76,25.03 20.76,23.53 v1(21.03,23.26)
  BOTTOM w0.102: v1(21.03,23.26) 21.03,23.03 21.64,22.42 23.12,22.42 23.93,23.23 24.87,23.23 25.04,23.4 U23.18
SD_CMD_R: length 5.9
  TOP w0.102: R1145.1 C814.1 18.24,20.32 18.24,19.5 v1(17.57,18.83)
  BOTTOM w0.102: v1(17.57,18.83) 18.02,18.39 18.02,17.85 17.8,17.63 CN16.4
SD_D0: length 19.3
  IN2 w0.14: v1(29.31,25.06) 28.14,25.06 27.88,25.31 27.88,27.25 27.33,27.81 24.9,27.81 24.43,27.34 24.43,26.64 24.31,26.51 24,26.51 23.87,26.64 23.87,27.44 23.73,27.58 23.45,27.58 23.31,27.44 23.31,26.85 23.19,26.72 22.88,26.72 22.76,26.85 22.76,27.34 22.62,27.48 22.34,27.48 22.2,27.34 22.2,26.41 22.07,26.28 21.77,26.28 21.64,26.41 21.64,27.34 21.5,27.48 21.2,27.48 20.71,27.97 20.71,28.79 v1(20.6,28.9)
  BOTTOM w0.102: U23.11 29.12,25.25 v1(29.31,25.06) ; R388.2 20.51,28.98 v1(20.6,28.9)
SD_D1: length 24.8
  IN2 w0.14: v1(29.31,25.75) 28.5,26.56 28.5,27.99 28.32,28.17 28.32,28.19 27.61,28.9 22.84,28.9 v1(22.76,28.97)
  BOTTOM w0.102: R389.2 21.33,30.95 21.44,31.05 21.44,32.49 21.56,32.62 23.25,32.62 23.37,32.5 23.37,32.33 23.25,32.21 22.07,32.21 21.97,32.11 21.97,31.91 22.07,31.81 23.25,31.81 23.37,31.69 23.37,31.52 23.25,31.4 22.07,31.4 21.97,31.3 21.97,31.09 22.07,30.99 23.25,30.99 23.37,30.87 23.37,30.71 23.25,30.59 22.07,30.59 21.97,30.49 21.97,29.76 v1(22.76,28.97) ; v1(29.31,25.75) U23.10
SD_D2: length 16.8
  IN2 w0.14: v1(23.28,25.58) 23.84,25.58 25.07,24.35 27.61,24.35 v1(28.12,23.84)
  BOTTOM w0.102: U23.21 23.46,25.75 v1(23.28,25.58) ; R1146.2 21.15,21.42 21.25,21.42 21.54,21.14 22.19,21.14 22.57,20.75 27.04,20.75 28.43,22.14 28.43,23.53 v1(28.12,23.84)
SD_D3: length 12.5
  TOP w0.102: R1147.2 20.74,22.27 v1(21.1,22.64) 21.1,22.11 21.23,21.99 21.59,21.99 21.72,22.11 v1(21.72,23.23)
  BOTTOM w0.102: v1(21.72,23.23) 22.15,22.8 22.4,22.8 22.58,22.97 22.58,23.31 21.6,24.28 21.6,24.45 21.71,24.56 21.88,24.56 22.74,23.71 22.92,23.71 23.04,23.83 23.04,24.01 22.18,24.88 22.18,25.14 22.3,25.26 22.58,25.26 23.02,24.82 23.11,24.82 23.53,25.25 U23.20
SD_D4: length 2.4
  BOTTOM w0.108: TP36.1 23.53,23.59 23.53,24.56 23.72,24.75 U23.19
SD_D5: length 2.5
  BOTTOM w0.108: U23.16 26.04,22.98 TP53.1
SD_D6: length 1.6
  BOTTOM w0.108: U23.14 27.04,22.63 TP54.1
SD_D7: length 2.5
  BOTTOM w0.108: TP55.1 30.25,24.5 28.96,24.5 28.71,24.75 U23.12
SD_DATA0_R: length 3.7
  BOTTOM w0.102: R388.1 18.79,29.25 19.21,29.68 C818.1 v1(18.52,30) 18.06,29.55 CN16.9
SD_DATA1_R: length 3.7
  BOTTOM w0.102: R389.1 C817.1 v1(18.52,31.97) 18.33,31.97 17.6,31.25 CN16.10
SD_DATA2_R: length 11
  BOTTOM w0.102: R1146.1 C815.1 v1(18.95,19.88) 18.95,18.27 17.93,17.26 17.93,12.83 17.73,12.63 CN16.2
SD_DATA3_R: length 15
  TOP w0.102: R1147.1 C819.1 18.91,19.98 18.91,19.5 16.77,17.35 15.32,17.35 v1(15.24,17.43)
  BOTTOM w0.102: CN16.3 14.51,15.12 14.26,15.38 14.26,16.56 14.46,16.77 14.77,16.77 14.86,16.68 14.86,15.89 15.03,15.72 15.28,15.72 15.43,15.87 15.43,17.24 v1(15.24,17.43)
SD_WP: length 22.2
  TOP w0.108: v1(32.23,31) 31.4,31.84 29.47,31.84 27.31,34 21.35,34 v1(21.01,33.66)
  BOTTOM w0.108: R390.2 20.3,32.95 v1(21.01,33.66) ; U23.8 31.79,26.75 32.74,27.7 32.74,30.09 32.23,30.59 v1(32.23,31)
SD_WP_R: length 2.4
  BOTTOM w0.108: R390.1 CN16.11
SDA_TO_EC: length 4.3
  TOP w0.102: R1173.1 R1152.1 144.65,37.5 U9.95
SDA_TO_EC_R: length 53
  TOP w0.102: v1(146.77,37.96) 146.48,38.26 R1152.2
  TOP w0.203: v1(123.18,21.31) 123.18,21.51 122.02,22.67 121.44,22.67 R1197.2 121.17,22.94 120.71,23.4 120.28,23.4 119.88,23.8 C335.1 119.79,23.98 U21.6
  IN2 w0.14: v1(146.77,37.96) 146.33,37.52 146.33,35.46 145.16,34.3 145.16,33.39 145.51,33.04 145.51,21.7 144.65,20.84 142.44,20.84 142.3,20.98 142.3,21.85 142.16,21.99 141.88,21.99 141.74,21.85 141.74,20.98 141.6,20.84 141.33,20.84 141.19,20.98 141.19,21.85 141.05,21.99 140.77,21.99 140.63,21.85 140.63,20.98 140.49,20.84 123.38,20.84 123.18,21.04 v1(123.18,21.31)
SDMMC3_COMP: length 3.9
  TOP w0.254: R346.2 81,77.94 v1(80.8,77.74) 80.8,77.08 80.05,76.33 v1(79.37,76.33)
  BOTTOM w0.305: v1(79.37,76.33) 79.37,76.19 U7.P12
SDREG: length 4
  BOTTOM w0.108: C423.2 29.46,28.17 v1(29.46,27.78) 28.74,27.78 27.79,28.73 27.66,28.73 27.54,28.61 U23.6
SDVO_CLK: length 60.3
  TOP w0.102: v1(23.12,77.92) 23.12,78.14 23.04,78.22 22.53,78.22 21.89,78.86 21.89,80.12 21.62,80.39 v1(21.11,80.39) 20.99,80.39 20.14,79.54 19.11,79.54 18.92,79.73 R7.2 18.92,80.29 18.45,80.75 Q1.4
  IN2 w0.14: v1(23.12,77.92) 23.37,78.16 26.09,78.16 28.58,80.65 30.42,80.65 31.76,79.32 35.68,79.32 38.34,81.98 38.34,83.68 41.01,86.35 42.24,86.35 42.45,86.14 48.06,86.14 49.92,84.28 49.92,81.64 50.1,81.46 50.1,77.85 51.78,76.18 52.05,76.18 v1(52.34,75.89)
  BOTTOM w0.102: U7.Y51 59.39,72.93 59.09,72.63 58.85,72.63 58.56,72.93 58.23,72.93 56.16,75 54.02,75 52.82,76.19 52.64,76.19 v1(52.34,75.89)
SDVO_DATA: length 61.3
  TOP w0.102: v1(23.12,78.68) 22.87,78.43 22.62,78.43 22.09,78.95 22.09,80.21 20.82,81.48 v1(20.82,84.46) 20.22,85.05 R6.2 19.69,84.38 19.75,84.32 Q1.1
  IN2 w0.14: v1(52.34,76.7) 52.08,76.44 51.89,76.44 50.37,77.96 50.37,81.58 50.19,81.75 50.19,84.39 48.17,86.41 42.56,86.41 42.35,86.62 40.9,86.62 38.07,83.79 38.07,82.09 35.57,79.58 31.87,79.58 30.53,80.92 28.47,80.92 25.98,78.43 23.37,78.43 v1(23.12,78.68)
  BOTTOM w0.102: v1(52.34,76.7) 52.64,76.39 52.91,76.39 54.1,75.2 56.24,75.2 58.31,73.13 58.77,73.13 U7.Y52
SENSEA: length 2.9
  TOP w0.203: R41.2 10.97,21.87 10.97,21.61 10.79,21.42 U4.13
  TOP w0.254: R41.2 R29.1
SENSOR_EN: length 165.7
  TOP w0.108: U9.70 141.63,27.5 141.62,27.5 v1(140.39,27.5) ; R780.2 R782.1 61.66,98.87 v1(62.31,98.87) 62.44,99.01 62.44,100.03 v1(62.43,100.04)
  IN1 w0.14: v1(62.43,100.04) 62.44,100.04 62.87,100.04 63.25,100.42 63.37,100.42 64.26,101.31 68.47,101.31 68.8,100.99 81.76,100.99 82.1,100.65 85.11,100.65 87.22,102.75 87.22,103.06 89.97,105.81 91.76,105.81 92.23,105.35 92.23,99.46 92.83,98.86 92.83,92.93 93.74,92.02 97.41,92.02 100.11,89.32 102.16,89.32 103.35,88.13 104.86,88.13 105.51,87.48 116.57,87.48 119.3,84.74 121.57,84.74 123.45,82.86 127.52,82.86 128.81,81.58 131.49,81.58 131.85,81.94 138.49,81.94 142.54,77.88 142.54,74.27 145.01,71.81 145.01,68.76 150.01,63.76 150.01,55.95 150.65,55.31 150.65,46.29 142.32,37.96 142.32,34.99 142,34.67 142,32.22 140.06,30.29 140.06,27.83 v1(140.39,27.5)
SERIRQ: length 98.9
  TOP w0.108: U9.5 127.48,36.3 127.56,36.21 127.98,36.21 128.22,36.46 128.22,36.8 127.78,37.24 127.78,38.19 v1(127.29,38.67)
  IN1 w0.14: v1(100.1,83.02) 100.28,83.02 101.32,81.98 104.42,81.98 104.7,81.7 105.35,81.7 106.03,82.38 108.33,82.38 109.81,80.9 113.32,80.9 115.17,79.05 117.38,79.05 117.94,78.5 119.18,78.5 120.23,77.45 120.23,75.55 120.53,75.24 121.69,75.24 122.08,75.63 122.87,75.63 124.02,74.49 124.02,73.65 124.29,73.38 124.67,73.38 126.09,74.8 127.56,74.8 129.16,73.2 129.16,73.14 129.97,72.33 130.7,72.33 131.74,71.29 131.74,70.6 131.98,70.35 132.59,70.35 134.01,68.93 134.65,68.93 135.79,67.79 v1(135.79,67.63)
  IN2 w0.14: v1(127.29,38.67) 126.7,39.26 125.95,39.26 124.29,40.92 123.27,40.92 122.8,41.39 122.8,41.79 122.28,42.3 122.28,48.12 122.82,48.65 122.82,49.13 123.88,50.19 124.54,50.19 125.37,51.02 125.37,52.4 126.86,53.9 130,53.9 130,53.9 131.47,53.9 131.65,54.08 132.75,54.08 134.42,55.76 135.39,55.76 136.85,57.22 136.85,60.19 135.24,61.8 135.24,66.09 135.79,66.64 v1(135.79,67.63)
  BOTTOM w0.108: v1(100.1,83.02) 98.6,83.02 98.29,83.33 U16.4 98.29,86.25 R431.2
SET1_VCORE: length 4
  TOP w0.254: v1(38.33,62.04) 38.84,61.53 PR39.2
  BOTTOM w0.203: PU4.7 39.69,62.8
  BOTTOM w0.254: 39.69,62.8 39.12,62.22 39.12,61.87 PR176.1 38.33,61.85 v1(38.33,62.04)
SET1_VGG: length 3.1
  TOP w0.203: v1(124.75,49.24) 124.41,49.24 v1(124.16,49.49) 123.94,49.71 PU6.7
  TOP w0.254: PR95.2 v1(124.75,49.24)
  BOTTOM w0.254: PR95.2 v1(124.75,49.24)
SET2_VCORE: length 4
  BOTTOM w0.203: PU4.8 39.29,62.98 38.99,62.68
  BOTTOM w0.254: 38.99,62.68 v1(38.25,62.68) 37.82,62.25 37.82,61.54 PR40.2 37.66,61.38 PR175.1
SET2_VGG: length 4.3
  TOP w0.203: PR99.2 125.7,49.6 v1(125.79,49.69) 125.55,49.93 124.44,49.93 124.34,50.03 PU6.8
  BOTTOM w0.254: PR99.2 125.7,49.6 v1(125.79,49.69)
SET3_VCORE: length 3.6
  TOP w0.254: v1(37.42,63.24) 36.87,62.69 PR41.2
  BOTTOM w0.203: PU4.9 38,64.12
  BOTTOM w0.254: v1(37.42,63.24) 37.02,63.24 PR174.1 36.81,63.6 37.21,64 37.52,64 v1(37.54,64.02) 37.64,64.12 38,64.12
SET3_VGG: length 6.1
  TOP w0.203: PU6.9 125.4,51.27 125.58,51.1
  TOP w0.254: v1(126.15,50.74) 125.93,50.74 125.58,51.1
  BOTTOM w0.254: PR203.1 PR88.2 128.99,51.71 128.91,51.63 128.26,51.63 v1(127.38,50.74) v1(126.15,50.74)
SETGND_VCORE: length 27.1
  TOP w0.254: v1(35.33,65.45) 35.92,64.86 35.92,64 v1(35.41,63.49) ; v1(37.71,58) 37.86,58.15 PR180.1 ; PR23.1 44.72,64 v1(43.96,64)
  IN1 w0.254: v1(37.71,58) 37.71,58.19 36.17,59.73 36.17,62.73 v1(35.41,63.49)
  IN2 w0.254: v1(43.96,64) 43.52,63.56 43.52,62.97 41.71,61.15 40.77,61.15 39.78,60.16 39.78,59.52 39.53,59.27 39.53,58.9 39.19,58.56 38.26,58.56 v1(37.71,58)
  BOTTOM w0.203: PU4.30 43.37,64.92 43.92,64.37 43.92,64.04 v1(43.96,64)
  BOTTOM w0.254: v1(43.96,64) 44.11,63.85 44.22,63.85 44.58,63.49 44.58,63.16 44.85,62.89 PR155.1 ; PC54.2 35.26,65.37 v1(35.33,65.45) 35.41,65.52 PR173.1 ; v1(37.71,58) 37.77,58.06 PR181.2 ; PR179.2 35.41,63.1 v1(35.41,63.49)
SETGND_VGG: length 21.5
  TOP w0.203: PU6.30 120.25,52.07 119.83,51.66 119.83,50.76 119.61,50.54 v1(119.61,50.49)
  TOP w0.254: PR202.2 117.46,51.76 117.87,51.76 PR196.1 118.1,51.38 118.44,51.04 118.8,51.04 118.98,50.86 PR200.1 119.01,50.49 v1(119.61,50.49)
  BOTTOM w0.254: PR206.1 PR208.2 124.75,46.08 124.18,46.65 v1(124.18,50.51) ; v1(119.61,50.49) 119.63,50.51 v1(124.18,50.51) ; v1(124.18,50.51) 125.17,51.5 125.17,52.24 126.23,53.29 PC72.2 PR198.1
SIO_EXT_SCI#: length 34
  TOP w0.108: v1(113.62,31.84) v1(114.31,32.54) 115.06,33.29 117.35,33.29 118.37,32.27 118.37,31.31 118.99,30.69 120.18,30.69 121,29.86 121,29.76 121.72,29.05 123.34,29.05 124.18,29.89 124.99,29.89 125.78,29.1 U9.23
  IN2 w0.14: v1(115.16,45.76) 115.23,45.69 115.23,41.39 114.2,40.36 114.2,37.13 113.23,36.17 113.23,32.96 113.62,32.58 v1(113.62,31.84)
  BOTTOM w0.108: U18.3 113.58,46.18 113.99,45.76 v1(115.16,45.76)
SIO_EXT_SMI#: length 30.5
  TOP w0.108: v1(130.45,38.4) 130.45,37.79 129.72,37.07 129.72,34.65 127.37,32.3 U9.15
  BOTTOM w0.108: U18.1 114.14,47.48 116.74,44.88 116.74,44.29 117.42,43.61 117.94,43.61 118.41,43.14 123.46,43.14 123.78,42.82 127.16,42.82 128.13,41.86 128.13,40.84 128.38,40.59 128.38,40.18 130.16,38.4 v1(130.45,38.4)
SLEEVE: length 1.6
  TOP w0.203: v1(8.84,21.83) 8.79,21.78 U4.18
  TOP w0.508: v1(8.84,21.83) 8.84,22.44 v1(8.89,22.49)
  vias: v1(8.46,31.44) v1(8.87,30.9)
SLEEVE_R:
  vias: v1(14.56,49.85)
SLP_A#: length 4.7
  TOP w0.108: R209.2 127.15,42.36 128.65,42.36 129.1,41.9 U9.126
SLP_S0IX#: length 79
  TOP w0.254: v1(110.68,82.24) 111.29,82.85 111.29,85.98 110.82,86.45 110.82,89.75 109.9,90.67 104.22,90.67 103.99,90.44 103.58,90.44 103.29,90.73 103.29,91.68 100.08,94.89 100.08,98.31 102.19,100.42 103.25,100.42 104.34,101.51 106.4,101.51 106.86,101.97 v1(107.27,101.97) v1(108.15,101.97)
  IN2 w0.254: v1(79.77,85.67) 81.63,85.67 83.11,87.16 91.43,87.16 91.93,86.66 93.21,86.66 94.38,85.5 94.38,85.23 94.69,84.92 95.84,84.92 96.92,83.85 98.2,83.85 99.55,82.5 100.72,82.5 101.6,81.62 104.98,81.62 105.6,82.24 v1(110.68,82.24)
  BOTTOM w0.102: 79.01,87.49 R307.2 79.77,86.48 v1(79.77,85.67) 79.77,85.61 79.38,85.22 79.38,84.47 78.49,83.58 78.49,82.6 U7.A13
  BOTTOM w0.254: 79.01,87.49 79.47,87.95 79.47,88.64 78.23,89.88 77.98,89.88 ; PR8.1 v1(108.15,101.97)
SLP_S3#: length 95.4
  TOP w0.254: PR233.1 113.46,106.34 112.8,105.68 112.6,105.68 112.35,105.43 112.35,104.82 113.01,104.16 114,104.16 115.67,102.49 115.67,99.67 116.83,98.5 116.83,97.48 120.2,94.12 120.2,91.5 119.82,91.12 119.82,87.86 121.67,86.01 121.67,81.95 124.49,79.12 v1(124.49,78.06)
  IN2 w0.254: v1(124.49,78.06) 124.29,78.06 124.16,78.19 122.44,78.19 122.14,78.49 120.56,80.07 119.99,80.07 119.14,80.93 117.32,80.93 116.71,81.53 115.43,81.53 114.2,82.76 105.35,82.76 v1(105.06,82.46) 104.95,82.36 104.95,82.31 104.72,82.08 102.91,82.08 102.11,82.88 101.82,82.88 101.29,83.4 100.5,83.4 100.22,83.68 99.13,83.68 98.56,84.24 97.09,84.24 95.25,86.08 94.35,86.08 93.38,87.05 92.11,87.05 91.61,87.55 84.83,87.55 84.11,88.27 83.68,88.27 83.01,87.59 83,87.59 81.6,86.2 79.55,86.2 78.61,85.26 v1(78.61,84.95)
  BOTTOM w0.102: U7.B14 77.72,82.3 78.26,82.85 78.26,83.64 79.14,84.53 79.14,85.26 78.79,85.61 78.29,85.61 R305.2 78.61,85.22 v1(78.61,84.95)
  BOTTOM w0.254: v1(105.06,82.46) 104.95,82.36 104.95,82.31 104.53,81.89 R451.1 104.34,81.89 103.89,82.34 103.68,82.34 103.53,82.18 Q36.4
SLP_S4#: length 55
  IN2 w0.102: 82.91,84.19 81.43,84.19 80.62,83.38 v1(79.45,83.38)
  IN2 w0.14: v1(108.04,79.65) 107.87,79.48 106.83,79.48 106.45,79.1 104.54,79.1 103.88,79.76 101.41,79.76 101.1,80.07 100.07,80.07 99.44,80.69 99.44,80.97 98.38,82.03 97.43,82.03 96.42,83.04 94.57,83.04 94.02,83.59 94.02,84.01 92.72,85.31 90.93,85.31 90.49,85.75 84.16,85.75 83.39,84.98 83.39,84.67 82.91,84.19
  BOTTOM w0.102: Q36.1 102.23,84.38 102.13,84.47 101.78,84.47 101.25,83.94 R453.1 100.97,84.55 101.68,85.26 101.68,85.73 102.49,86.53 102.49,86.88 102.85,87.24 104.11,87.24 104.77,86.58 105.33,86.58 v1(105.82,86.1) 106.38,86.1 107.44,85.03 107.44,83.01 107.02,82.59 106.53,82.59 106.31,82.36 Q38.5 106.31,81.11 106.73,80.69 106.73,80 R320.2 107.92,79.86 108.04,79.75 v1(108.04,79.65) ; U7.C12 78.69,81.51 79.08,81.9 79.21,81.9 79.48,82.17 79.48,82.6 79.53,82.65 79.53,83.3 v1(79.45,83.38)
SLP_SUS#_EC: length 125.5
  TOP w0.108: U9.19 127.41,30.7 127.71,31 129.46,31 130.28,31.82 v1(130.28,32.73)
  IN1 w0.14: v1(83.52,94.02) 84.03,94.53 86.58,94.53 87.5,93.61 87.5,92.56 88.91,91.16 89.46,91.16 92.42,88.2 92.42,88.04 93.38,87.09 94.03,87.09 94.47,86.65 95.2,86.65 95.62,86.23 96.75,86.23 98.54,84.43 100.14,84.43 101.01,83.56 101.71,83.56 102.65,82.62 104.43,82.62 104.76,82.94 108.56,82.94 109.95,81.55 109.95,81.55 110.04,81.46 113.6,81.46 115.45,79.61 117.61,79.61 118.17,79.05 120.12,79.05 120.83,78.35 122.92,78.35 123.95,77.32 126.29,77.32 127.42,76.19 128.84,76.19 129.49,75.54 131.03,75.54 133.9,72.67 134.76,72.67 135.66,71.78 135.66,71.06 136.62,70.1 136.62,69.22 139.5,66.33 139.5,63.84 141.1,62.24 141.1,57.52 140.6,57.02 140.6,50.7 138.05,48.15 138.05,47.23 136.91,46.09 136.91,44.64 136.64,44.37 136.43,44.37 134.01,41.94 134.01,41.03 132.29,39.31 128.67,39.31 128.4,39.04 128.4,38.28 129.06,37.62 129.06,33.95 v1(130.28,32.73)
  BOTTOM w0.108: v1(83.52,94.02) 83.37,94.02 v1(82.86,93.51) 82.06,92.71 79.79,92.71 78.74,91.66 77.08,91.66 R430.2
SMB_RUN_CLK: length 44.5
  TOP w0.108: R1190.1 113.27,51.48 113.27,52.61 R432.2 113.72,53.61 113.67,53.66 U15.6 113.67,55.42 v1(113.82,55.57) ; v1(119.76,22.19) 119.79,22.16 120.07,22.16 120.25,21.98 R1198.1
  IN2 w0.14: v1(113.82,55.57) 114.11,55.57 114.73,54.94 114.73,53.27 114.68,53.22 114.68,49.76 115.94,48.5 115.94,45.23 115.51,44.8 115.51,41.28 114.48,40.24 114.48,37.02 113.51,36.06 113.51,33.25 114.2,32.57 114.2,31.89 115.72,30.37 116.61,30.37 117.12,29.86 v1(117.12,29.56)
  BOTTOM w0.108: v1(117.12,29.56) 117.12,24.45 118.95,22.62 119.33,22.62 v1(119.76,22.19)
SMB_RUN_DAT: length 45.1
  TOP w0.108: R1197.1 120,22.94 119.81,23.13 v1(119.76,23.13) ; R1191.1 113.05,51.44 113.05,52.64 R434.2 112.87,53.06 113.17,53.36 U15.5 113.17,55.81 v1(113.21,55.84)
  IN2 w0.14: v1(117.78,29.53) 117.78,29.73 116.87,30.65 115.9,30.65 114.48,32.07 114.48,32.68 113.84,33.32 113.84,35.99 114.76,36.9 114.76,40.13 115.79,41.16 115.79,44.68 116.22,45.12 116.22,48.61 114.96,49.88 114.96,53.1 115.01,53.16 115.01,55.06 114.02,56.05 113.41,56.05 v1(113.21,55.84)
  BOTTOM w0.108: v1(119.76,23.13) 119.64,23.26 119.53,23.26 117.78,25.01 v1(117.78,29.53)
SMB_SOC_ALERTB: length 8.7
  TOP w0.127: R196.2 87.71,66.28 v1(87.12,66.28) 86.77,66.28 85.73,67.33 83.41,67.33 83.24,67.15 81.22,67.15 v1(80.8,67.57)
  BOTTOM w0.102: v1(80.8,67.57) U7.AM9
SMB_SOC_CLK: length 48.5
  TOP w0.102: v1(87.7,69.25) 87.7,68.7 88.88,67.51 R419.2 86.41,67.48 86.34,67.55 83.52,67.55 83.1,67.97 82.63,67.97 v1(82.22,67.57) ; v1(114.02,56.63) 113.67,56.98 U15.3
  BOTTOM w0.102: U7.AM6 v1(82.22,67.57) ; v1(114.02,56.63) 113.54,57.11 113.29,57.11 112.9,56.73 112.9,56.56 111.98,55.63 111.98,55.25 110.59,53.86 108.65,53.86 v1(107.79,54.72) 105.89,54.72 105.28,55.33 100.56,55.33 100.33,55.56 100.33,57.75 96.8,61.28 95.62,61.28 92.24,64.66 92.24,65.8 91.82,66.22 91.82,66.92 90.65,68.09 89.95,68.09 88.8,69.23 88.8,69.39 88.53,69.66 88.11,69.66 v1(87.7,69.25)
SMB_SOC_DATA: length 48.5
  TOP w0.102: v1(113.36,56.61) 113.36,56.77 113.17,56.96 U15.4 ; v1(88.36,69.25) 88.36,68.6 88.52,68.43 R418.2 89.04,68.89 88.86,69.07 88.86,69.37 88.57,69.66 87.53,69.66 87.25,69.38 87.25,68.9 86.14,67.8 83.59,67.8 83.21,68.18 82.54,68.18 82.38,68.01 81.95,68.01 v1(81.51,67.57)
  BOTTOM w0.102: U7.AM7 v1(81.51,67.57) ; v1(113.36,56.61) 113.36,56.58 112.28,55.5 112.28,55.12 110.72,53.56 v1(108.33,53.56) 107.47,54.42 105.76,54.42 105.16,55.02 100.44,55.02 100.03,55.43 100.03,57.62 96.68,60.98 95.49,60.98 91.94,64.53 91.94,65.68 91.52,66.1 91.52,66.79 90.53,67.78 89.82,67.78 v1(88.36,69.25)
SOC_CLKOUT_0: length 9.7
  BOTTOM w0.102: R112.2 v1(91.05,79.03) 90.21,79.03 89.65,78.46 88.86,78.46 86.79,76.39 85.18,76.39 84.63,75.84 U7.P2
SOC_CLKOUT_1: length 12.1
  BOTTOM w0.102: R121.2 92.7,78.54 R120.2 91.96,78.32 90.24,78.32 89.9,77.98 v1(89.24,77.98) 88.82,77.98 87.03,76.19 85.27,76.19 84.72,75.64 84.05,75.64 83.91,75.51 83.62,75.51 U7.R3
SOC_CLKRUN#: length 8.9
  BOTTOM w0.102: R126.2 90.12,77.5 88.78,77.5 87.26,75.99 85.79,75.99 85.54,75.73 85.54,75.31 85.3,75.07 84.05,75.07 83.95,75.16 83.7,75.16 83.41,74.87 U7.T3
SOC_DDI1_RCOMP: length 1.3
  TOP w0.114: R341.1 62.39,79.3 v1(61.77,79.3)
  BOTTOM w0.102: U7.F47 61.77,79.72 v1(61.77,79.3)
SOC_DDI1_RCOMP_P: length 1.8
  TOP w0.114: v1(61.26,80.1) 62.37,80.1 R341.2
  BOTTOM w0.102: U7.F49 60.96,79.8 v1(61.26,80.1)
SOC_DDIO_RCOMP: length 1.5
  TOP w0.114: v1(65.57,80.32) 65.79,80.1 66.03,80.1 R342.1
  BOTTOM w0.102: v1(65.57,80.32) U7.F38
SOC_DDIO_RCOMP_P: length 1.5
  TOP w0.114: v1(65.57,79.61) 65.79,79.83 66.04,79.83 R342.2
  BOTTOM w0.102: v1(65.57,79.61) U7.G38
SOC_DRAM_PWROK: length 178.2
  TOP w0.089: C284.1 71.63,61.69 71.23,62.08 71.23,62.74 v1(70.45,63.53)
  IN1 w0.14: v1(109.88,79.51) 112.98,79.51 114.39,78.1 114.39,74.03 115.26,73.16 118.38,73.16 119.26,74.04 120.82,74.04 123.09,71.78 124.62,71.78 125.43,72.58 128.93,72.58 129.74,71.77 130.47,71.77 131.16,71.08 131.16,70.38 131.75,69.79 132.35,69.79 133.78,68.37 134.42,68.37 135.05,67.75 135.05,66.85 134.52,66.33 134.52,62.77 137.4,59.89 137.4,55.44 139.19,53.66 139.19,50.99 134.81,46.61 134.81,45.41 134.41,45.01 134.41,44.1 131.78,41.48 131.78,40.95 131.35,40.52 130.36,40.52 129.99,40.89 v1(129.99,41.11)
  IN2 w0.089: v1(70.45,63.53) 71.3,62.67 71.3,59.55 70.49,58.75 70.49,57.12 71.14,56.48 71.14,55.91
  IN2 w0.119: 103,42.37 102.24,42.37 102.07,42.2 101.28,42.2 100.95,41.87 100.95,36.57 98.55,34.17 88.93,34.17 88.4,34.7 85.48,34.7 84.66,35.52 80.42,35.52 79.78,36.17 79.59,36.17 78.96,36.8 78.96,43.01 74.44,47.53 71.25,47.53 69.71,49.08 69.71,50.57 69.48,50.79 69.48,51.6 70.08,52.2 70.08,52.58 70.46,52.97 70.46,54.75 71.14,55.44 71.14,55.91
  IN2 w0.14: v1(105.97,44.65) 105.43,44.65 103.16,42.37 103,42.37
  BOTTOM w0.089: v1(70.45,63.53) U7.AV28
  BOTTOM w0.108: v1(109.88,79.51) 109.88,79.03 108.6,77.76 106.25,77.76 R452.2 ; v1(105.97,44.65) 106.94,44.65 107.78,45.49 107.78,46.31 107.6,46.5 107.6,47.58 108.54,48.51 110.97,48.51 111.31,48.18 113.74,48.18 116.96,44.96 116.96,44.38 117.5,43.83 118.03,43.83 118.5,43.36 123.55,43.36 123.87,43.04 128.07,43.04 v1(129.99,41.11)
SOC_GPIO_RCOMP: length 3.7
  TOP w0.102: R368.2 62.93,69.99 64.42,69.99 v1(64.49,70.07) 64.57,69.99 65.03,69.99 v1(65.56,69.46)
  BOTTOM w0.254: v1(65.56,69.46) 65.56,69.41 U7.AH40
SOC_KBC_SCI: length 45.1
  IN1 w0.14: v1(109.73,46.83) 109.77,46.87 109.77,49.58 110.92,50.73 110.92,52.03 108.1,54.85 108.1,56.99 108.64,57.52 108.64,62.48 106.25,64.87 102.85,64.87 101,63.02 101,62.74 100.66,62.4 100.66,61.97 100.33,61.63 100.33,61.28 v1(100.28,61.23)
  BOTTOM w0.108: R181.2 90.69,68.56 92.21,67.03 92.21,66.33 92.6,65.95 92.6,64.81 95.61,61.79 97.03,61.79 97.77,61.05 100.1,61.05 v1(100.28,61.23) ; v1(109.73,46.83) 109.73,46.38 R499.1 109.93,46.18 U18.4
SOC_KCB_SMI: length 42.2
  IN1 w0.14: v1(110.39,46.83) 110.05,47.17 110.05,49.46 111.2,50.61 111.2,52.19 108.38,55.01 108.38,56.87 108.94,57.43 108.94,62.59 106.38,65.15 102.73,65.15 100.72,63.13 100.72,62.85 100.18,62.31 100.18,62.17 v1(100.15,62.14)
  BOTTOM w0.108: v1(100.15,62.14) 100.13,62.12 100.13,61.89 99.72,61.48 97.87,61.48 97.23,62.12 96.02,62.12 R1019.2 93.29,65.03 93.57,65.32 93.96,65.32 94.07,65.43 R1018.2 ; U18.6 110.45,48.1 R498.1 109.92,47.3 v1(110.39,46.83)
SOC_OVERRIDE_NM: length 1.6
  BOTTOM w0.108: Q16.2 30.74,92.81 R295.1
SOC_PCIE_COMN: length 1.7
  TOP w0.102: v1(72.35,80.32) 72.35,80.49 72.25,80.6 72.01,80.6 R344.2
  BOTTOM w0.102: U7.F26 71.94,79.9 v1(72.35,80.32)
SOC_PCIE_COMP: length 1.7
  TOP w0.102: v1(72.35,81.03) 72.35,80.9 72.25,80.8 71.83,80.8 R344.1
  BOTTOM w0.102: v1(72.35,81.03) 71.86,80.54 U7.D26
SOC_PLTRST#: length 45.7
  IN2 w0.102: v1(78.22,80.37) 80.65,82.8 80.65,83.1 81.48,83.94 83.14,83.94 83.39,84.19
  IN2 w0.14: 83.39,84.19 83.54,84.34 84.38,84.34 85.47,85.44 90.2,85.44 90.86,84.78 v1(91.09,84.78) 91.19,84.88 92.7,84.88 93.7,83.88 93.7,83.46 94.15,83.01 94.44,82.72 96.29,82.72 97.3,81.71 98.25,81.71 99.12,80.83 99.12,80.56 99.93,79.75 100.79,79.75 101.17,79.37 102.79,79.37 v1(103.2,78.97)
  BOTTOM w0.102: v1(78.22,80.37) 78.13,80.37 U7.F14 ; R322.1 92.85,94.95 92.99,94.8 Q39.1 92.99,91.68 92.52,91.21 91.88,91.21 v1(91.54,90.87) 91.11,90.44 91.11,87.53 90.48,86.9 90.48,85.64 91.09,85.04 v1(91.09,84.78) ; v1(103.2,78.97) 103.21,78.96 103.21,77.69 103.64,77.25 D22.1
SOC_PMC_WAKE: length 41.7
  TOP w0.108: v1(95.88,73.96) 95.88,74.46 96.19,74.77 96.19,75.24 96.71,75.76 96.98,75.76 100.89,79.67 100.89,80.89 100.41,81.37 v1(100.31,81.37)
  IN1 w0.102: v1(77.22,76.67) 77.32,76.77 78.03,76.77 78.92,77.66 80.72,77.66 80.87,77.82 83.57,77.82
  IN1 w0.14: v1(95.23,84.4) 96.87,84.4 99.91,81.37 v1(100.31,81.37) ; 83.57,77.82 83.85,77.82 84.37,77.3 88.07,77.3 88.21,77.16 92.16,77.16 92.75,76.57 92.75,75.88 93.02,75.61 94.5,75.61 95.88,74.22 v1(95.88,73.96)
  BOTTOM w0.102: U7.N16 76.85,76.41 v1(77.22,76.67)
  BOTTOM w0.108: v1(95.23,84.4) 94.9,84.4 94.88,84.38 R81.2 95.05,84.93 95.37,84.93 95.69,84.61 95.69,83.89 95.79,83.79 U17.4
SOC_PROCHOT#: length 16.4
  IN2 w0.102: v1(59.87,71.45) 59.44,71.89 58.57,71.89 56.33,71.89 56.01,71.57 55.51,71.57 54.88,72.21
  IN2 w0.14: 54.88,72.21 52.66,72.21 52.29,72.57 52.29,72.83 52.02,73.11 51.47,73.11 51.2,72.84 v1(49.19,72.84)
  BOTTOM w0.102: R132.1 49.61,72.01 48.91,71.31 R136.2 48.38,72.34 C86.2 48.4,72.36 48.88,72.84 v1(49.19,72.84) ; v1(59.87,71.45) 60.36,70.96 U7.AD50
SOC_PWRBTN#: length 25.4
  IN2 w0.102: 86.94,81.61 84.23,81.61 83.59,80.97 83.59,80.41 82.68,79.49 81.74,79.49 79.95,77.71 78.83,77.71 78.6,77.47 77.38,77.47 v1(77.24,77.33)
  IN2 w0.14: 86.94,81.61 88.37,81.61 88.9,82.14 89.98,82.14 90.51,81.61 93.57,81.61 93.62,81.56 94.81,81.56 v1(94.84,81.52)
  BOTTOM w0.102: v1(77.24,77.33) 76.94,77.12 U7.M16
  BOTTOM w0.108: R221.1 97.09,84.4 U17.6 97.09,83.14 96.6,82.64 95.38,82.64 94.84,82.11 v1(94.84,81.52)
SOC_REST_BTN#: length 11.3
  BOTTOM w0.102: U7.AF2 84.04,70.22 84.78,70.22 84.9,70.1 85.24,70.1 86.15,71.01 86.72,71.01
  BOTTOM w0.108: R172.2 93.44,69.36 92.57,70.23 v1(91.75,70.23) 91.55,70.03 89.98,70.03 89,71.01 86.72,71.01
SOC_RSMRST#: length 23.3
  IN2 w0.102: 80.49,84.19 80.34,84.04 77.41,84.04 76.35,82.98 76.35,81.73 75.82,81.19 75.82,80.74 v1(76.24,80.32)
  IN2 w0.14: v1(91.19,86.58) 91,86.39 83.16,86.39 81.87,85.09 81.4,85.09 80.49,84.19
  BOTTOM w0.102: R177.2 92.84,87.17 R166.2 91.78,87.17 v1(91.19,86.58) 91.19,86.32 91.85,85.66 R160.2 ; U7.F18 76.23,80.31 v1(76.24,80.32)
SOC_RTEST#: length 85.3
  TOP w0.102: R38.2 C42.1 143.5,97.67 G1.1 143.8,97.18 142.95,96.33 v1(142.95,96.31)
  IN2 w0.14: v1(128.17,84.78) 128.17,85.11 128.8,85.74 137.3,85.74 139.21,87.65 v1(139.21,87.91) ; v1(92.69,83.61) 92.81,83.61 93.04,83.38 93.04,83.22 94.18,82.08 95.06,82.08 95.75,81.39 96.72,81.39 98.27,79.83 98.95,79.83 99.67,79.12 100.41,79.12 101.42,78.11 108,78.11 108.5,78.62 108.5,79.01 109.65,80.16 113.59,80.16 115.28,78.46 117.87,78.46 117.96,78.37 118.93,78.37 119.81,77.49 119.81,75.51 120.4,74.93 121.74,74.93 122.42,75.61 123.9,75.61 123.98,75.69 v1(124.64,75.69)
  BOTTOM w0.102: v1(124.64,75.69) 125.27,76.32 125.27,76.82 126.47,78.01 126.47,78.79 125.81,79.45 125.81,82.41 v1(128.17,84.78) ; v1(142.95,96.31) 142.95,91.45 140.29,88.79 140.09,88.79 v1(139.21,87.91) ; Q75.3 96.35,88.1 96.03,87.78 95.66,87.78 95.24,87.36 95.24,86.63 94.95,86.35 93.5,86.35 92.84,85.68 92.84,84.56 92.96,84.43 92.96,83.91 92.69,83.63 v1(92.69,83.61) 92.48,83.4 R1209.1
SOC_RTEST#_R: length 18.5
  IN2 w0.102: 86.64,84.06 84.18,84.06 82.53,82.41 80.67,82.41 78.77,80.51 78.77,78.95 78.21,78.4 77.83,78.4 77.33,78.9 v1(77.23,78.9)
  IN2 w0.14: v1(90.22,84.06) 90,84.29 86.86,84.29 86.64,84.06
  BOTTOM w0.102: v1(77.23,78.9) U7.J16
  BOTTOM w0.108: v1(90.22,84.06) 90.45,84.06 91.11,83.4 R1209.2
SOC_SERIRQ: length 75.9
  TOP w0.102: v1(97.27,74.76) 97.27,75.29 100.57,78.59 v1(101.71,78.59)
  IN2 w0.14: v1(127.74,77.33) 128.22,76.84 128.88,76.84 v1(129.29,77.26)
  BOTTOM w0.102: U7.T2 83.83,74.87 85.38,74.87 85.74,75.23 85.74,75.65 85.88,75.78 87.42,75.78 88.73,77.1 94.29,77.1 94.54,76.85 95.33,76.85 96.08,76.1 96.08,75.14 96.5,74.72 97.22,74.72 v1(97.27,74.76) ; v1(129.29,77.26) 129.29,79.34 R1013.1 R1200.2 130.33,79.39 130.99,79.39 131.26,79.66 131.26,80.83 131.11,80.98 U11.3 ; v1(127.74,77.33) 127.07,77.33 126.34,76.59 126.34,76.03 125.57,75.26 125.57,74.13 124.75,73.31 124.75,72.3 124.25,71.8 121.07,71.8 120.82,72.05 113.47,72.05 113.37,72.15 113.37,72.62 112.81,73.18 112.34,73.18 111.15,74.37 106.81,74.37 105.13,76.04 104.16,76.04 102.62,77.59 102.16,77.59 101.71,78.04 v1(101.71,78.59) 101.29,79.01 100.98,79.01 100.68,79.31 100.01,79.31 R428.2 99.09,80.23 98.49,80.23 98.17,80.55 98.17,81.12 98.29,81.23 U16.3 98.29,82.89 97.79,83.39 97.79,86.25 R431.1
SOC_SPI_CLK: length 62.8
  IN2 w0.102: 88.77,73.01 88.75,73.01 88.63,72.89 86.77,72.89 86.51,73.14 86.15,73.14 v1(85.71,73.58)
  IN2 w0.14: v1(124.48,73.84) 124.48,73.82 123.84,73.18 122.74,73.18 122.54,72.98 119.76,72.98 118.9,72.12 114.67,72.12 113.58,71.03 112.83,71.03 111.16,69.36 99.87,69.36 96.95,72.28 95.46,72.28 95.46,72.28 94.53,72.28 93.87,72.94 91.43,72.94 91.36,73.01 88.77,73.01
  BOTTOM w0.102: v1(85.71,73.58) 85.55,73.75 84.67,73.75 84.62,73.7 84.06,73.7 83.77,73.42 U7.W3 ; v1(124.48,73.84) 124.48,74.5 123.85,75.13 123.85,76.12 124.44,76.7 124.44,77.42 124.91,77.89 124.91,79.24 121.47,82.68 121.47,84.31 v1(120.9,84.88) 120.84,84.93 120.84,88.17 R75.2
SOC_SPI_CLK_R: length 2.6
  BOTTOM w0.102: U5.6 v1(118.29,88.72) 118.56,88.99 R75.1
SOC_SPI_CLK_R1: length 15.5
  TOP w0.102: U9.105 137.5,40.38 137.94,40.82 138.11,40.82 139.15,41.86 v1(139.15,42.07)
  BOTTOM w0.102: v1(139.15,42.07) 138.23,42.07 137.48,42.81 136.89,42.81 136.79,42.71 136.79,41.95 136.69,41.85 136.49,41.85 136.38,41.95 136.38,42.71 136.28,42.81 136.08,42.81 135.98,42.71 135.98,41.95 135.88,41.85 135.67,41.85 135.57,41.95 135.57,42.71 135.47,42.81 135.34,42.81 134.95,43.2 134.95,44.85 135.33,45.23 136.04,45.23 136.27,45.46 U14.6
SOC_SPI_CS#: length 71.6
  IN2 w0.14: v1(123.24,74.61) 123.23,74.6 122.7,74.6 122.12,74.01 119.33,74.01 118.47,73.15 114.24,73.15 113.15,72.06 112.41,72.06 110.74,70.39 100.29,70.39 97.38,73.31 94.99,73.31 94.29,74.01 91.82,74.01 91.78,74.04 88.27,74.04 88.24,74.01 84.66,74.01 84.09,73.43 v1(82.93,73.43)
  BOTTOM w0.102: v1(123.24,74.61) 123.13,74.71 123.13,76.41 123.72,77 123.72,77.85 116.46,85.11 v1(116.45,85.11) 116.34,85.22 110.57,85.22 110.56,85.23 108.89,85.23 106.78,87.34 106.22,87.34 105.82,87.75 105.48,87.75 R102.2 105.47,88.03 106.02,88.03 106.07,87.98 R96.2 ; v1(82.93,73.43) 82.57,73.85 U7.V4
SOC_SPI_CS#_R: length 3.1
  BOTTOM w0.102: U5.1 108.56,86.18 v1(107.68,87.05) 107.15,87.59 R96.1
SOC_SPI_CS#_R1: length 25.1
  TOP w0.102: v1(142.06,39.84) 141.35,39.84 141.06,39.55 141.06,38.74 140.87,38.55 139.38,38.55 139.1,38.83 U9.101
  BOTTOM w0.102: R175.2 U14.1 133.73,51.98 134.74,50.96 135.44,50.96 137.97,48.43 137.97,44.6 v1(138.47,44.1) 140.06,42.51 140.06,41.48 141.7,39.84 v1(142.06,39.84)
SOC_SPI_MISO_R: length 3.2
  BOTTOM w0.102: U5.2 108.28,87.45 107.83,87.89 v1(107.83,88.56) 107.83,88.56 R85.1
SOC_SPI_MISO_R1: length 26.8
  TOP w0.102: v1(143.08,39.84) 141.18,37.94 139.13,37.94 138.3,38.77 U9.103
  BOTTOM w0.102: v1(143.08,39.84) 142.44,40.48 142.07,40.48 141.24,41.31 141.24,44.28 v1(139.73,45.78) 138.28,47.23 138.28,49.36 R183.1 137.03,49.99 135.76,51.27 134.87,51.27 134.65,51.49 134.65,52.54 135,52.9 U14.2
SOC_SPI_MOSI_R: length 2.6
  BOTTOM w0.102: R68.1 118.87,90.01 118.75,90.13 v1(118.26,90.13) 118.12,89.99 U5.5
SOC_SPI_MOSI_R1: length 14.3
  TOP w0.102: v1(141.6,39.39) 141.6,38.84 141,38.24 139.25,38.24 138.7,38.8 U9.102
  BOTTOM w0.102: U14.5 137.54,44.54 137.08,44.08 R218.1 137.61,43.12 138.68,43.12 v1(138.98,42.82) 139.76,42.04 139.76,41.35 141.6,39.51 v1(141.6,39.39)
SOC_USB_OC0#: length 181.9
  TOP w0.108: v1(99.5,89.14) 99.04,88.68 99.04,87.11 100.52,85.63 100.52,82.17 99.89,81.54 99.89,81.19 100.13,80.95 100.43,80.95 100.67,80.71 100.67,79.83 98.66,77.82 R99.1 98.35,77.44 96.89,75.97 96.62,75.97 95.96,75.32 95.96,74.87 95.23,74.13 v1(95.23,74.08)
  IN1 w0.102: v1(77.95,76.33) 78.42,76.8 83.57,76.8
  IN1 w0.14: v1(95.23,74.08) 95.2,74.11 95.2,74.41 94.28,75.33 92.9,75.33 92.47,75.77 92.47,76.46 92.05,76.88 83.64,76.88 83.57,76.8 ; v1(20.35,57.65) 22.15,59.45 22.15,64.49 23.72,66.06 23.72,71.98 21.05,74.66 21.05,76.33 21.86,77.14 21.86,79.54 21.17,80.23 21.17,80.66 19.31,82.53 19.31,86.58 21.77,89.04 21.77,91.98 25.01,95.21 28.21,95.21 30.17,93.25 35.11,93.25 38.32,96.47 46.3,96.47 47.46,97.62 53.19,97.62 55.65,100.08 61.01,100.08 61.68,99.41 62.73,99.41 63.39,100.07 69.27,100.07 69.9,100.71 81.64,100.71 81.98,100.37 85,100.37 85,100.37 85.23,100.37 87.5,102.64 87.5,102.95 90.09,105.53 91.65,105.53 91.95,105.23 91.95,99.34 92.51,98.78 92.51,92.86 93.63,91.74 97.29,91.74 99.5,89.53 v1(99.5,89.14)
  BOTTOM w0.102: v1(77.95,76.33) U7.P14
  BOTTOM w0.108: U36.3 22.41,58.22 21.85,57.65 v1(20.35,57.65)
