# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IN_D0: length 68.1
  IN2 w0.102: v1(57.32,82.31) 57.62,82.62 57.62,82.77 57.42,82.97 56,82.97 54.87,84.11 54.87,85.53 55.23,85.9 55.23,86.49 51.55,90.17 51.55,90.34 50.75,91.14 50.75,91.71 50.25,92.21 47.87,92.21 46.18,93.89 43.41,93.89 42.7,93.18 38.05,93.18 35.43,90.57 28.97,90.57 26.74,92.8 22.64,92.8 22.1,92.26 22.1,88.81 20.65,87.36 20.65,81.97 19.61,80.93 19.61,79.19 18.34,77.92 17.71,77.92 17.53,77.74 v1(17.53,77.54)
  BOTTOM w0.102: U7.F53 58.51,79.87 58.4,79.87 58.37,79.9 58.04,80.24 58.04,81.35 57.61,81.78 57.61,82.02 v1(57.32,82.31)
  BOTTOM w0.114: v1(17.53,77.54) 17.53,77.69 17.43,77.79 17.18,77.79 16.56,77.16 16.15,77.16 16.01,77.02 C10.1
IN_D0#: length 68.1
  IN2 w0.102: v1(58.1,82.31) 57.82,82.59 57.82,82.86 57.51,83.18 56.08,83.18 55.07,84.19 55.07,85.45 55.44,85.81 55.44,86.58 51.76,90.26 51.76,90.42 50.95,91.22 50.95,91.79 50.34,92.41 47.95,92.41 46.26,94.1 43.33,94.1 42.61,93.39 37.96,93.39 35.35,90.77 29.06,90.77 26.82,93.01 22.56,93.01 21.9,92.34 21.9,88.89 20.45,87.44 20.45,82.06 19.41,81.02 19.41,79.27 18.26,78.12 17.74,78.12 v1(17.53,78.33)
  BOTTOM w0.102: U7.F52 58.97,80.15 58.41,80.15 58.24,80.32 58.24,81.43 57.81,81.86 57.81,82.02 v1(58.1,82.31)
  BOTTOM w0.114: C11.1 16.24,77.43 16.44,77.43 17.07,78.05 17.26,78.05 v1(17.53,78.33)
IN_D1: length 73.6
  IN2 w0.102: v1(61.1,79.33) 60.9,79.53 60.9,79.81 60.81,79.9 60.81,80.41 61.01,80.61 61.01,81.45 60.28,82.18 59.31,82.18 59.06,82.44 59.06,83.36 58.56,83.86 56.39,83.86 55.75,84.5 55.75,85.16 56.26,85.67 56.26,86.83 55.46,87.63 55.46,88.25 54.8,88.92 54.26,88.92 51.64,91.53 51.64,92.08 50.61,93.11 48.29,93.11 46.36,95.04 43.27,95.04 42.33,94.1 37.67,94.1 35.46,91.89 28.93,91.89 27.13,93.69 24.44,93.69 23.72,94.41 22.18,94.41 21.21,93.44 21.21,89.25 19.05,87.09 19.05,81.68 18.7,81.33 18.7,79.75 18.31,79.37 17.96,79.37 17.8,79.53 17.8,79.66 v1(18.1,79.96)
  BOTTOM w0.102: U7.H49 60.85,79.08 v1(61.1,79.33)
  BOTTOM w0.114: v1(18.1,79.96) 17.82,79.69 17.82,79.42 17.45,79.05 16.38,79.05 C4.1
IN_D1#: length 73.6
  IN2 w0.102: v1(17.3,79.96) 17.42,79.96 17.6,79.79 17.6,79.45 17.87,79.17 18.4,79.17 18.9,79.67 18.9,81.24 19.25,81.6 19.25,87.01 21.41,89.17 21.41,93.35 22.27,94.21 23.63,94.21 24.35,93.49 27.04,93.49 28.85,91.68 35.55,91.68 37.76,93.89 42.42,93.89 43.36,94.83 46.28,94.83 48.21,92.9 50.52,92.9 51.44,91.99 51.44,91.45 54.17,88.71 54.72,88.71 55.26,88.17 55.26,87.55 56.06,86.75 56.06,85.76 55.55,85.25 55.55,84.41 56.3,83.66 58.47,83.66 58.85,83.28 58.85,82.35 59.23,81.98 60.19,81.98 60.81,81.36 60.81,80.69 60.61,80.49 60.61,79.82 60.7,79.73 60.7,79.52 60.5,79.33 v1(60.39,79.33)
  BOTTOM w0.102: v1(60.39,79.33) 60.14,79.08 U7.H50
  BOTTOM w0.114: C5.1 16.01,79.39 16.09,79.31 17.34,79.31 17.56,79.53 17.56,79.87 17.47,79.96 v1(17.3,79.96)
IN_D2: length 64.8
  IN2 w0.102: v1(22.45,80.95) 22.75,81.24 23.15,81.24 23.45,81.54 23.45,86.88 25.23,88.66 27.15,88.66 28.37,89.88 35.72,89.88 37.1,91.25 41.74,91.25 43.67,93.18 45.92,93.18 47.58,91.52 49.33,91.52 50.84,90.01 50.84,89.57 53.94,86.47 53.94,83.38 55.14,82.18 55.8,82.18 56.38,81.6 57.37,81.6 57.8,81.17 59.68,81.17 59.85,81 59.85,80.73 v1(59.72,80.6)
  BOTTOM w0.102: v1(59.72,80.6) 59.78,80.66 U7.D50
  BOTTOM w0.114: C8.1 16.35,74.95 16.82,74.95 18.97,77.1 18.97,80.08 20.17,81.27 22.14,81.27 v1(22.45,80.95)
IN_D2#: length 64.8
  IN2 w0.102: v1(22.45,81.74) 22.75,81.45 23.06,81.45 23.24,81.63 23.24,86.96 25.15,88.86 27.06,88.86 28.28,90.08 35.64,90.08 37.01,91.46 41.66,91.46 43.59,93.39 46,93.39 47.67,91.72 49.41,91.72 51.04,90.1 51.04,89.66 54.15,86.55 54.15,83.46 55.22,82.39 55.88,82.39 56.47,81.8 57.46,81.8 57.89,81.37 59.76,81.37 59.95,81.18 v1(60.3,81.18)
  BOTTOM w0.102: U7.C51 60.27,81.14 v1(60.3,81.18)
  BOTTOM w0.114: v1(22.45,81.74) 22.25,81.54 20.06,81.54 18.71,80.19 18.71,77.21 16.71,75.21 16.43,75.21 C9.1
INT_EDP_AUXN: length 20.9
  IN2 w0.102: v1(69.47,91.36) 69.22,91.62 69.22,91.86 68.99,92.09 68.45,92.09 67.39,91.03 67.39,82.54 67.01,82.16 67.01,79.65 65.63,78.27 64.33,78.27 63.82,77.77 63.78,77.77 v1(63.58,77.97)
  BOTTOM w0.102: v1(63.58,77.97) 63.71,77.84 U7.K42
  BOTTOM w0.114: C70.2 69.22,92.27 69.22,91.61 v1(69.47,91.36)
INT_EDP_AUXP: length 20.9
  IN2 w0.102: v1(68.71,91.36) 68.83,91.36 69.01,91.54 69.01,91.78 68.9,91.89 68.53,91.89 67.59,90.95 67.59,82.46 67.21,82.08 67.21,79.57 65.71,78.07 64.42,78.07 63.91,77.56 63.67,77.56 v1(63.43,77.32)
  BOTTOM w0.102: v1(63.43,77.32) 63.78,76.97 U7.M42
  BOTTOM w0.114: v1(68.71,91.36) 68.96,91.61 68.96,92.27 C63.2
INT_EDP_TXN0: length 36.5
  IN2 w0.102: v1(73.54,92.03) 73.26,92.31 73.26,92.62 72.88,93 72.04,93 71.55,93.49 67.9,93.49 65.56,91.15 65.56,87.24 65.96,86.84 65.96,84.43 65.53,84 65.53,83.62 65.39,83.48 65.39,82.81 64.97,82.39 64.15,82.39 63.48,81.71 63.28,81.71 62.69,81.12 62.69,80.21 62.23,79.74 62.23,79.1 62.02,78.89 59.72,78.89 57.97,80.64 56.6,80.64 v1(56.23,81)
  BOTTOM w0.102: U7.H51 59.41,78.79 58.31,78.79 57.02,80.08 57.02,80.37 56.73,80.66 56.57,80.66 v1(56.23,81)
  BOTTOM w0.114: v1(73.54,92.03) 73.4,92.17 73.4,92.27 73.4,92.27 73.4,92.73 C80.1
INT_EDP_TXN1: length 34.5
  IN2 w0.102: v1(56.34,79.56) 56.64,79.26 56.79,79.26 57,79.47 58.12,79.47 60,77.59 62.27,77.59 62.56,77.87 62.56,78.55 62.92,78.91 62.92,79.14 63.98,80.2 63.98,81.23 64.41,81.66 65.35,81.66 66.08,82.38 66.08,83.17 66.25,83.34 66.25,83.74 66.7,84.19 66.7,87.11 66.24,87.57 66.24,90.86 68.19,92.8 70.87,92.8 71.19,92.48 71.19,92.05 71.35,91.9 v1(71.54,91.9)
  BOTTOM w0.114: v1(71.54,91.9) 71.28,91.9 71.19,91.99 71.19,92.51 71.32,92.64 C812.1 ; U7.K52 58.83,77.93 57.52,77.93 57,78.45 57,79.04 56.8,79.23 56.66,79.23 v1(56.34,79.56)
INT_EDP_TXP0: length 36.5
  IN2 w0.102: v1(72.78,92.03) 73.06,92.31 73.06,92.54 72.8,92.8 71.95,92.8 71.47,93.28 67.98,93.28 65.76,91.07 65.76,87.33 66.17,86.92 66.17,84.34 65.74,83.91 65.74,83.54 65.6,83.4 65.6,82.73 65.05,82.18 64.24,82.18 63.56,81.51 63.36,81.51 62.89,81.04 62.89,80.12 62.43,79.66 62.43,79.01 62.11,78.69 59.63,78.69 57.89,80.43 56.45,80.43 v1(56.23,80.22)
  BOTTOM w0.102: U7.J51 59.02,78.59 58.23,78.59 56.82,79.99 56.82,80.28 56.65,80.46 56.47,80.46 v1(56.23,80.22)
  BOTTOM w0.114: v1(72.78,92.03) 73.13,92.38 73.13,92.8 72.96,92.97 C79.1
INT_EDP_TXP1: length 34.5
  IN2 w0.102: v1(56.34,78.76) 56.64,79.06 56.87,79.06 57.08,79.26 58.03,79.26 59.91,77.38 62.36,77.38 62.76,77.79 62.76,78.47 63.12,78.82 63.12,79.05 64.19,80.12 64.19,81.15 64.49,81.45 65.44,81.45 66.28,82.3 66.28,83.09 66.45,83.26 66.45,83.66 66.9,84.11 66.9,87.2 66.45,87.65 66.45,90.78 68.27,92.6 70.79,92.6 70.99,92.4 70.99,92.11 v1(70.77,91.9)
  BOTTOM w0.114: v1(56.34,78.76) 56.34,78.89 56.47,79.02 56.71,79.02 56.78,78.95 56.78,78.36 57.43,77.71 58.62,77.71 58.85,77.49 59.09,77.49 59.39,77.79 U7.K51 ; v1(70.77,91.9) 70.92,92.05 70.92,92.38 C813.1
IOAC_RST#: length 88.5
  TOP w0.108: v1(147.88,32.11) 147.65,32.33 145.15,32.33 144.83,32.65 144.83,32.94 144.51,33.27 143.3,33.27 143.07,33.5 U9.85 ; v1(151.08,98.21) 151.18,98.21 152.45,99.48 152.63,99.48 153.19,100.04 153.59,100.04 153.87,99.76 155.03,99.76 R297.2
  IN1 w0.14: v1(151.08,98.21) 151.08,98.04 147.65,94.61 147.65,83.02 147.2,82.57 147.2,79.98 147.41,79.77 147.41,77.91 148.06,77.27 148.06,76.57 148.59,76.04 152.56,76.04 154.62,73.98 154.62,69.18 153.97,68.53 153.97,57.58 154.62,56.93 154.62,41.6 152.92,39.9 152.92,39.32 150.7,37.1 149.78,37.1 149.03,36.34 149.03,34.9 148.69,34.56 148.69,32.91 v1(147.88,32.11)
IOAC_WLANPWR#: length 100.3
  TOP w0.108: v1(133.94,25.2) 133.59,24.86 129.17,24.86 129.1,24.79 U9.35 ; v1(141.3,77.97) 141.71,78.37 v1(141.71,79.29) 141.71,79.59 142.23,80.12 142.23,80.95 142.44,81.17 142.44,84.32 142.29,84.47 142.29,86.22 142.69,86.63 146.45,86.63 147.24,87.42 147.24,93.86 148.44,95.05 148.44,99.38 148.71,99.65 148.71,100.21 148.22,100.69 147.3,100.69 R128.2
  IN1 w0.14: v1(133.94,25.2) 134.26,25.52 134.79,25.52 134.97,25.33 136.67,25.33 137.72,26.39 137.72,29.92 139.25,31.45 139.25,34.01 140.52,35.27 140.52,39.38 141.97,40.82 141.97,42.03 142.34,42.4 144.34,42.4 144.86,42.92 144.86,44.63 145.73,45.49 145.73,47.72 147.45,49.45 147.45,56.37 148.49,57.41 148.49,59.21 147.97,59.72 147.97,65.01 144.45,68.53 144.45,71.58 141.98,74.04 141.98,77.49 141.5,77.97 v1(141.3,77.97)
ISEN1N_VCORE: length 1.7
  BOTTOM w0.102: 43.7,66.18 43.64,66.12
  BOTTOM w0.203: 43.64,66.12 PU4.27
  BOTTOM w0.254: 43.7,66.18 43.72,66.21 PR25.1
ISEN1N_VGG: length 2.1
  TOP w0.203: v1(119.76,53.54) 120.03,53.27 PU6.27
  BOTTOM w0.254: PR74.1 119.58,53.72 v1(119.76,53.54)
ISEN1P_VCORE: length 8
  TOP w0.254: v1(44.17,65.57) 44.17,65.94 PR21.1
  BOTTOM w0.203: v1(44.17,65.57) 44.02,65.72 PU4.28
  BOTTOM w0.254: PR20.1 48.22,62.82 48.08,62.96 v1(48.03,62.96) 46.67,62.96 PC24.2 45.83,63.85 44.17,65.51 v1(44.17,65.57)
ISEN1P_VGG: length 7.7
  TOP w0.203: PU6.28 v1(119.48,52.87) 119.17,52.56 PC70.2
  IN1 w0.254: v1(118.93,55.49) 118.93,53.43 v1(119.48,52.87)
  BOTTOM w0.254: v1(118.93,55.49) 118.8,55.49 117.85,56.44 PR63.2 ; PR72.1 119.18,52.87 v1(119.48,52.87)
L_SPK+: length 29.8
  IN2 w0.889: 11.41,15.51 12.03,16.13 12.04,16.13 12.62,16.72 12.62,21.55 13.79,22.72 16.94,22.72 18.68,20.98 19.19,20.98 20.12,21.91 25.8,21.91 26.03,21.68 27.16,21.68 30.2,24.72 30.2,26.61 30.76,27.17
  vias: v1(8.09,13.16) v1(8.09,12.5) v1(31.37,27.65) v1(32.03,27.65)
L_SPK+_1:
  vias: v1(33.96,27.63) v1(34.62,27.63)
L_SPK-: length 27.7
  IN2 w0.889: 11.99,14.29 13.77,16.07 13.77,20.59 14.73,21.55 16.43,21.55 18.16,19.83 19.66,19.83 20.6,20.77 25.3,20.77 25.55,20.51 27.62,20.51 31.32,24.22
  vias: v1(8.75,13.16) v1(8.75,12.5) v1(31.17,26.1) v1(31.17,25.44)
L_SPK-_1:
  vias: v1(33.96,25.84) v1(34.62,25.84)
LAD0: length 125
  TOP w0.102: v1(132.95,78.39) 132.94,78.4 132.1,78.4 131.76,78.74 R238.2 ; U9.10 125.82,34.3 124.86,35.26 124.86,36.86 v1(125.05,37.05)
  IN2 w0.14: v1(125.05,37.05) 125.05,37.9 123.23,39.72 122.4,39.72 121.89,40.23 121.76,40.23 121.54,40.23 120.38,41.38 120.38,41.52 120.38,41.52 120.38,42.13 120.38,44.47 120.63,44.71 120.63,47.7 120.78,47.86 121.94,49.02 121.94,49.49 123.52,51.07 124.17,51.07 124.49,51.39 124.49,53.15 128.16,56.82 128.62,56.82 129.37,56.07 129.37,55.77 130.36,54.77 131.1,54.77 131.29,54.96 132.38,54.96 134.15,56.73 135.12,56.73 135.97,57.58 135.97,59.83 134.36,61.44 134.36,66.45 134.78,66.87 134.78,67.64 133.75,68.66 133.75,73.07 133.04,73.78 133.04,76.44 133.36,76.76 133.36,77.84 132.95,78.25 v1(132.95,78.39)
  BOTTOM w0.102: v1(132.95,78.39) 132.66,78.11 132.66,76.96 131.87,76.17 U13.26 130.38,76.17 130.03,76.51 129.02,76.51 128.73,76.8 126.89,76.8 126.57,76.48 126.57,75.93 125.8,75.16 125.8,74.03 124.98,73.22 124.98,72.2 124.34,71.57 120.97,71.57 120.72,71.82 111.27,71.82 109.57,73.52 106.45,73.52 104.77,75.2 102.39,75.2 98.42,79.17 98.05,79.17 96.8,80.42 89.24,80.42 86.22,77.41 84.76,77.41 84.37,77.02 84.05,77.02 83.97,77.11 83.7,77.11 83.41,76.82 U7.M3
LAD0_C: length 50.6
  TOP w0.102: v1(133.4,78.87) 133.28,78.99 R238.1 ; CN5.64 159.01,96 158.34,96.66 155.11,96.66 154.45,96 152.91,96 v1(152.53,95.62)
  IN2 w0.14: v1(133.4,78.87) 133.49,78.95 139.74,78.95 139.82,78.88 141.46,78.88 142.63,77.71 142.63,75.98 144.35,74.26 145.71,74.26 147.28,75.83 147.28,79.65 146.45,80.48 146.45,85.68 146.91,86.15 146.91,92.48 149.22,94.78 151.69,94.78 v1(152.53,95.62)
LAD1: length 124.8
  TOP w0.102: R239.2 131.87,79.46 133.39,79.46 133.9,78.96 133.9,78.51 v1(133.67,78.27) ; v1(125.45,36.54) 125.43,36.52 125.35,36.52 125.08,36.25 125.08,35.43 125.81,34.7 U9.9
  IN2 w0.14: v1(133.67,78.27) 133.63,78.23 133.63,76.65 133.3,76.33 133.3,73.89 134.02,73.18 134.02,68.77 135.05,67.75 135.05,66.76 134.63,66.34 134.63,61.55 136.24,59.94 136.24,57.47 135.14,56.37 134.68,56.37 134.17,56.37 132.49,54.69 131.4,54.69 131.22,54.51 130.25,54.51 128.87,55.89 127.86,55.89 124.76,52.79 124.76,51.28 124.28,50.8 123.63,50.8 122.21,49.38 122.21,48.91 120.89,47.59 120.89,44.6 120.65,44.35 120.65,42.02 120.65,42.02 120.65,41.63 120.65,41.63 120.65,41.49 121.65,40.5 122,40.5 122.51,39.99 123.34,39.99 125.6,37.72 125.6,36.69 v1(125.45,36.54)
  BOTTOM w0.102: U7.M2 84.46,76.82 84.85,77.21 86.34,77.21 89.33,80.2 96.7,80.2 97.96,78.94 98.33,78.94 102.3,74.97 104.68,74.97 106.36,73.29 109.47,73.29 111.17,71.59 120.63,71.59 120.88,71.34 124.44,71.34 125.24,72.14 125.24,73.15 125.67,73.58 126.93,73.58 127.09,73.73 129.34,73.73 129.83,74.22 U13.23 131.82,74.22 132.58,74.98 132.58,75.9 133.19,76.51 133.19,77.24 133.67,77.72 v1(133.67,78.27)
LAD1_C: length 52.1
  TOP w0.076: CN5.66 159.41,95.5
  TOP w0.102: v1(134.84,78.49) 134.69,78.49 133.22,79.96 R239.1 ; v1(152.15,94.4) 152.15,94.63 153.26,95.74 155.82,95.74 155.9,95.81 158.63,95.81 158.95,95.5 159.41,95.5
  IN2 w0.14: v1(134.84,78.49) 134.96,78.61 141.32,78.61 142.36,77.57 142.36,75.87 144.24,73.99 145.83,73.99 147.55,75.72 147.55,79.76 146.71,80.59 146.71,85.41 147.3,85.99 147.3,92.49 149.21,94.4 v1(152.15,94.4)
LAD2: length 119.1
  TOP w0.102: R241.2 133.71,76.53 v1(134.1,76.53) ; U9.8 125.83,35.1 125.5,35.43 v1(125.5,35.88)
  IN2 w0.14: v1(125.5,35.88) 125.62,36.01 125.86,36.01 126.23,36.38 126.23,36.89 126.71,37.37 126.71,38.63 126.42,38.92 125.8,38.92 124.15,40.58 123.13,40.58 122.45,41.25 122.45,41.65 121.94,42.16 121.94,48.26 122.47,48.8 122.47,49.27 123.74,50.53 124.4,50.53 125.03,51.16 125.03,52.58 127.28,54.83 129.55,54.83 130.14,54.24 131.33,54.24 131.51,54.42 132.6,54.42 134.28,56.1 134.56,56.1 134.57,56.1 135.25,56.1 136.51,57.36 136.51,60.05 134.9,61.66 134.9,66.23 135.31,66.65 135.31,67.86 134.29,68.88 134.29,73.29 133.57,74 133.57,76.01 v1(134.1,76.53)
  BOTTOM w0.102: v1(134.1,76.53) 133.04,75.47 133.04,74.42 131.87,73.25 131.87,72.42 131.72,72.27 U13.20 130.27,72.27 130.17,72.36 128.72,72.36 128.48,72.12 127.12,72.12 126.92,71.92 126.92,71.71 125.72,70.51 124.85,70.51 124.25,71.11 120.49,71.11 120.24,71.36 111.08,71.36 109.38,73.06 106.26,73.06 104.58,74.74 102.2,74.74 98.23,78.71 97.86,78.71 96.61,79.97 89.43,79.97 86.46,77 84.93,77 84.54,76.61 84.05,76.61 83.95,76.52 83.66,76.52 U7.N3
LAD2_C: length 49.4
  TOP w0.102: v1(134.22,77.49) 133.53,77.49 R241.1 ; v1(152.3,93.74) 152.58,94.02 152.58,94.39 153.59,95.39 158.36,95.39 158.75,95 CN5.68
  IN2 w0.14: v1(152.3,93.74) 152.1,93.94 151.95,93.94 151.77,94.12 149.31,94.12 147.68,92.49 147.68,85.83 146.98,85.14 146.98,80.7 147.82,79.87 147.82,75.61 145.94,73.73 144.13,73.73 142.43,75.42 142.09,75.76 142.09,76.53 140.35,78.27 135.54,78.27 135.09,77.82 134.55,77.82 v1(134.22,77.49)
LAD3: length 121.1
  TOP w0.102: v1(129.11,38.4) 128.76,38.05 128.76,35.86 128.4,35.5 U9.7 ; R245.2 135.84,76.36 135.41,76.79 v1(135.21,76.79)
  IN2 w0.14: v1(129.11,38.4) 129.11,39 125.31,42.8 125.31,47.13 125.24,47.2 125.24,49.79 125.7,50.26 126.68,50.26 128.21,51.79 130.76,51.79 131.09,52.11 131.69,52.11 134.72,55.15 135.64,55.15 137.46,56.96 137.46,60.45 136.95,60.96 136.95,67.91 136.39,68.47 135.95,68.47 135.3,69.12 135.3,69.65 135.48,69.83 135.48,72.16 134.82,72.82 134.82,73.51 134.1,74.22 134.1,75.36 135.21,76.47 v1(135.21,76.79)
  BOTTOM w0.102: U7.N1 84.54,76.33 85.01,76.8 86.58,76.8 89.52,79.74 96.51,79.74 97.77,78.48 98.14,78.48 102.11,74.51 104.49,74.51 106.17,72.83 109.28,72.83 110.98,71.14 120.14,71.14 120.88,70.4 121.56,70.4 122.6,69.36 124.32,69.36 124.42,69.46 124.42,70.01 124.53,70.11 124.73,70.11 124.83,70.01 124.83,69.46 124.93,69.36 125.13,69.36 125.24,69.46 125.24,70.01 125.34,70.11 125.54,70.11 125.64,70.01 125.64,69.46 125.74,69.36 126.34,69.36 126.77,69.79 128.5,69.79 128.6,69.89 129.31,69.89 129.66,70.24 130.18,70.24 130.25,70.32 U13.17 131.76,70.32 131.88,70.44 131.88,71.03 132.7,71.85 132.7,73.76 133.27,74.33 133.27,74.99 135.06,76.79 v1(135.21,76.79)
LAD3_C: length 48.8
  TOP w0.076: CN5.70 159.41,94.5
  TOP w0.102: v1(151.36,93.64) 151.82,93.64 152.15,93.31 152.48,93.31 152.81,93.64 152.81,94.22 153.29,94.71 155.31,94.71 155.52,94.5 159.41,94.5 ; R245.1 137.06,76.85 136.15,76.85 v1(136.11,76.81)
  IN2 w0.14: v1(136.11,76.81) 137.04,77.74 139.05,77.74 141.02,75.77 141.33,75.77 143.91,73.19 146.16,73.19 148.35,75.39 148.35,80.09 147.51,80.93 147.51,84.92 148.29,85.69 148.29,92.34 149.07,93.13 150.93,93.13 151.36,93.56 v1(151.36,93.64)
LED_PWR: length 5
  TOP w0.508: v1(64.65,100.69) R114.2 R1207.2
  BOTTOM w0.508: v1(64.65,100.69) 64.65,100.16 64.36,99.86 64.36,97.41
LFRAME#: length 127.8
  TOP w0.102: v1(128.22,37.39) 128.53,37.08 128.53,36.24 128.19,35.9 U9.6 ; v1(134.59,76.96) 134.59,76.96 134.85,77.22 134.85,77.51 135.2,77.87 137.13,77.87 R236.1
  IN2 w0.14: v1(134.59,76.96) 134.63,76.92 134.63,76.26 133.84,75.47 133.84,74.11 134.55,73.4 134.55,72.71 135.21,72.04 135.21,70.6 v1(134.78,70.16) 134.65,70.04 134.65,69.39 135.84,68.2 136.28,68.2 136.66,67.82 136.66,60.87 137.19,60.34 137.19,57.08 135.53,55.41 134.57,55.41 131.87,52.71 126.26,52.71 125.71,52.17 125.71,50.88 124.28,49.45 124.28,49.16 122.63,47.51 122.63,42.44 123.14,41.93 123.14,41.53 123.41,41.26 124.43,41.26 126.09,39.61 127.01,39.61 127.75,38.87 127.75,37.86 v1(128.22,37.39)
  BOTTOM w0.102: v1(134.59,76.96) 134.59,76.95 134.54,77 133.59,77 133.42,76.83 133.42,76.42 132.81,75.81 132.81,74.52 131.86,73.57 U13.22 ; v1(134.78,70.16) 134.78,69.62 134.5,69.34 133.38,69.34 132.09,68.05 130.27,68.05 130.07,67.85 127.21,67.85 125.93,69.13 122.5,69.13 121.46,70.17 120.79,70.17 120.65,70.3 120.05,70.91 110.89,70.91 109.19,72.61 106.07,72.61 104.4,74.29 102.01,74.29 98.05,78.25 97.67,78.25 96.42,79.51 89.9,79.51 v1(89.62,79.23) 89.34,79.23 86.7,76.6 85.1,76.6 84.55,76.05 84.05,76.05 83.95,76.15 83.71,76.15 83.41,75.84 U7.P3
LFRAME#_C: length 45.8
  TOP w0.102: v1(136.1,77.46) 136.61,77.46 R236.2
  IN2 w0.14: v1(150.7,93.61) 150.52,93.79 149.36,93.79 147.96,92.39 147.96,85.74 147.25,85.03 147.25,80.81 148.08,79.98 148.08,75.5 146.05,73.46 144.02,73.46 141.44,76.04 141.13,76.04 139.16,78.01 136.64,78.01 v1(136.1,77.46)
  BOTTOM w0.102: v1(150.7,93.61) 150.7,92.88 151.49,92.09 154.36,92.09 156.02,93.75 CN5.73
LGATE_VCORE: length 17.5
  IN1 w0.762: v2(40.23,69.13) 39.04,70.32 34.47,70.32 34.1,70.69 34.1,75.86 35.32,77.08 37.82,77.08 v2(38.74,77.99)
  vias: v1(38.66,78.68)
LGATE_VGG: length 6.9
  TOP w0.203: v2(122.97,55.88) 123.14,55.72 PU6.20
  IN2 w0.762: v2(125.6,60.04) 124.66,60.04 123.76,59.14 123.76,58.54 122.97,57.75 v2(122.97,55.88)
  vias: v1(126.16,59.12)
LID#: length 104.5
  TOP w0.108: R1001.2 C597.1 158.73,101.83 158.92,101.64 158.92,100.79 158.7,100.57 157.66,100.57 157.38,100.29 156.67,100.29 156.31,100.65 154.59,100.65 v1(154.26,100.32) ; U9.118 132.3,38.83 135.43,35.69 135.43,34.79 136.09,34.13 139.75,34.13 v1(140.26,33.62)
  IN1 w0.14: v1(154.26,100.32) 154.23,100.29 154.23,99.69 153.34,98.8 153.34,95.57 152.78,95.01 150.93,95.01 149.51,93.59 v1(149.51,92.01)
  IN2 w0.14: v1(151.56,43.37) 153.14,44.95 153.14,68.62 154.46,69.94 154.46,73.9 151.87,76.5 150.65,76.5 149.63,77.51 v1(149.63,77.56)
  BOTTOM w0.108: v1(149.51,92.01) 148.91,91.42 148.91,78.28 v1(149.63,77.56) ; v1(151.56,43.37) 151.56,41.04 149.73,39.2 D43.1 149.23,38.8 145.47,35.04 145.47,32.15 144.93,31.61 144.45,31.61 144.02,31.18 143.39,31.18 141.39,33.18 140.7,33.18 v1(140.26,33.62)
LID#_1: length 248.2
  TOP w0.108: v1(151.13,99.15) 151.26,99.15 R281.2 152.93,100.83 153.44,100.83 153.65,101.03 153.65,101.74 153.82,101.92 154.26,101.92 154.84,101.34 D12.1 155.78,102.25 156.52,102.25 156.95,102.68 MR1.2 156.95,103.57 157.11,103.73 R1001.1 ; v1(146.23,103.06) 146.03,103.27 146.03,104.67 144.71,105.98 143.39,105.98 142.93,106.44 142.93,108.65 142.11,109.47 R990.1 141.37,109.06 141.78,109.06 142.01,108.83 C573.2 141.6,108.12 141.6,106.4 D29.1 142.5,105.5 142.5,104.87 142.38,104.75 MR3.4
  IN1 w0.14: v1(43.74,19.52) 43.97,19.75 45.31,19.75 46.29,20.73 48.93,20.73 51.56,23.36 56.56,23.36 57.29,22.62 70.01,22.62 72.11,20.52 72.11,19.4 73.33,18.17 73.33,17.14 74.24,16.23 74.55,16.23 100.58,16.23 104.03,19.68 125.72,19.68 125.98,19.94 141.59,19.94 142.8,21.15 145.33,21.15 146.84,22.66 146.84,26.58 149.25,28.99 149.25,34.33 149.59,34.67 149.59,35.2 153.48,39.08 153.48,39.67 155.18,41.37 155.18,74.21 152.79,76.6 148.82,76.6 148.62,76.8 148.62,79.35 147.75,80.21 147.75,82.22 148.21,82.67 148.21,93.54 151.59,96.92 151.59,98.44 151.13,98.9 v1(151.13,99.15) 151.09,99.11 150.71,99.11 148.25,101.57 147.12,101.57 146.23,102.46 v1(146.23,103.06)
  IN2 w0.14: v1(43.74,19.52) 42.98,19.52 41.5,21 41.5,21.2 41.2,21.5 37.87,21.5 37.21,22.16 37.21,25.77 35.26,27.73 v1(35.26,28.54)
  BOTTOM w0.108: v1(35.26,28.54) 35.18,28.46 34.34,28.46 D15.1
LID_OPEN_OUT2_R_L: length 3.7
  TOP w0.108: MR3.1 140.88,105.23 141,105.35 v1(141,105.43) 141,105.43 C575.2 D30.1 141,107.68 140.96,107.72 R991.1
LINE1-L: length 37.6
  TOP w0.203: 6.55,21.81 6.86,21.81 7.19,21.48 U4.22
  TOP w0.381: 6.55,21.81 5.94,21.81 v1(5.79,21.96)
  IN2 w0.381: v1(5.79,21.96) 5.08,22.67 5.08,23.18 2.9,25.36 2.9,30.89 4.02,32.02 5.9,32.02 7.11,33.23 7.11,34.97 8.86,36.72 13.67,36.72 15.71,38.76 15.71,40.38 16,40.67 16,43.68 v1(17.5,45.17)
  BOTTOM w0.381: C28.1 17.71,44.8 17.71,44.96 v1(17.5,45.17)
LINE1-R: length 37.6
  TOP w0.203: v1(7.52,21.81) 7.59,21.74 U4.21
  IN2 w0.381: v1(18.26,45.15) 18.26,45.11 16.79,43.64 16.79,41.01 17.08,40.72 17.08,39.59 16.47,38.98 16.47,38.48 14.12,36.13 10.38,36.13 9.61,35.37 8.34,35.37 7.7,34.73 7.7,32.99 6.14,31.44 5.66,31.44 5.66,31.44 4.27,31.44 3.48,30.65 3.48,25.62 5.67,23.43 5.67,22.98 6.83,21.81 7.52,21.81 v1(7.52,21.81)
  BOTTOM w0.381: v1(18.26,45.15) 18.26,45.8 C25.1
LINE1-VREFO-L: length 36.3
  TOP w0.203: v1(4.36,17.65) 4.42,17.6 U4.31
  BOTTOM w0.381: v1(4.36,17.65) 4.36,17.79 3.53,18.62 3.53,29.72 8.74,34.93 9.82,34.93 11.23,36.34 14.89,36.34 v1(16.43,37.87) 17.56,39 17.56,40.56 16.91,41.21 16.91,42.4 17.71,43.2 R26.2
LINE1-VREFO-R: length 41.5
  TOP w0.203: v1(3.46,17.91) 3.66,18.11 4.55,18.11 4.67,18 U4.30
  IN1 w0.381: v1(17.63,47.79) 17.5,47.67 17.5,47.37 15.7,45.56 15.7,38.27 14.02,36.59 9.15,36.59 8.69,36.13 8.69,34.8 3.71,29.83 3.71,18.16 v1(3.46,17.91)
  BOTTOM w0.381: v1(17.63,47.79) 17.66,47.76 R28.2
LPC_RCOMP: length 3
  TOP w0.102: R363.1 84.72,76.55 v1(83.92,75.76) 83.5,75.34 v1(82.93,75.34)
  BOTTOM w0.102: U7.T4 v1(82.93,75.34)
LX_1P8:
  vias: v1(110.87,103.72)
M_A_A0: length 72.7
  TOP w0.089: U24.N3 44.57,42.74 44.68,42.86 44.91,42.86 45.07,42.71 45.45,42.71 45.54,42.62 45.54,42.51 45.46,42.44 45.46,42.13 45.74,41.85 46,41.85 46.21,42.06 46.21,42.23 46.29,42.31 46.44,42.31 v3(46.61,42.13) ; v3(64.29,42.22) 64.15,42.22 63.69,41.76 63.34,41.76 63.06,42.05 63.06,42.24 63.27,42.45 63.27,42.69 63.16,42.8 62.58,42.8 U25.N3
  IN1 w0.089: 60.77,59.76 61.41,60.39 61.41,60.48 61.66,60.73 61.66,60.73 61.79,60.86 61.79,61.04 v1(61.13,61.7)
  IN1 w0.102: 60.77,59.76 60.77,59.54 60.61,59.37 59.95,59.37 59.85,59.27 59.85,59.17 59.75,59.07 59.55,59.07 59.54,59.07 59.44,59.17 59.44,59.72 59.34,59.82 59.17,59.82 59.07,59.72 59.07,58.84 58.54,58.3 58.54,58.18 58.52,58.16
  IN1 w0.135: v1(52.55,41.64) 52.53,41.61 52.53,41.36 52.62,41.26 52.62,40.81 52.46,40.65 51.96,40.65 51.73,40.88 51.73,42.01 52.71,43 52.71,43.34 52.66,43.4 52.66,44.15 51.52,45.29 51.52,47.16 51.82,47.46 51.82,48.45 51.82,48.45 51.82,50.36 51.82,50.36 51.82,50.65 52.21,51.05 52.21,52.89 52.79,53.46 52.79,53.72 52.72,53.79 52.72,54.04 52.97,54.29 53.22,54.29 53.29,54.22 53.54,54.22 53.79,54.47 53.79,54.72 53.72,54.79 53.72,55.04 53.97,55.3 54.22,55.3 54.3,55.22 54.55,55.22 55.93,56.61 56.57,56.61 56.96,56.61 58.52,58.16
  IN2 w0.102: v3(64.29,42.22) 63.84,41.78 63.31,41.78 63.28,41.75 60.83,41.75 60.63,41.54 58.23,41.54 57.77,42.01 57,42.01 56.67,42.34 54.82,42.34 54.1,41.62 52.57,41.62 v1(52.55,41.64) 52.03,41.64 51.91,41.52 51.91,41.08 51.59,40.76 51.43,40.76 51.33,40.86 51.33,41.14 51.5,41.31 51.5,41.59 51.37,41.72 51.17,41.72 51.07,41.62 51.07,41.57 50.97,41.47 50.76,41.47 50.66,41.57 50.66,41.62 50.56,41.72 50.36,41.72 50.23,41.59 50.23,40.92 50.12,40.81 49.58,40.81 49.44,40.95 49.44,41.62 49.34,41.72 49.09,41.72 48.98,41.62 48.98,40.96 48.88,40.85 48.74,40.85 48.45,41.14 48.45,41.41 48.35,41.51 48.11,41.51 47.98,41.64 47.98,41.82 48.08,41.92 48.47,41.92 48.57,42.02 48.57,42.17 48.41,42.33 47.69,42.33 47.59,42.22 47.59,41.72 47.46,41.59 47.32,41.59 47.14,41.77 46.98,41.77 v3(46.61,42.13)
  BOTTOM w0.089: v1(61.13,61.7) 61.56,62.14 U7.BB47 ; U31.N3 47.77,42.69 47.68,42.78 47.55,42.78 47.48,42.71 47.4,42.71 47.27,42.58 47.17,42.58 47.03,42.72 46.89,42.72 46.69,42.52 46.56,42.52 46.45,42.62 46.31,42.62 46.21,42.53 46.21,42.09 46.13,42.01 46.13,41.88 46.22,41.79 46.35,41.79 46.52,41.97 46.52,42.05 46.61,42.13 v3(46.61,42.13) ; U32.N3 65.35,42.57 65.22,42.44 65.22,42.36 65.09,42.23 64.86,42.23 64.56,42.53 64.56,42.59 64.16,42.99 63.95,42.99 63.69,42.74 63.69,42.61 63.82,42.48 64.02,42.48 v3(64.29,42.22)
  BOTTOM w0.117: v1(52.55,41.64) 52.74,41.44 R1049.2
M_A_A1: length 80.2
  TOP w0.089: U25.P7 65.4,41.91 64.82,41.91 64.73,41.82 64.73,41.68 64.82,41.59 65.04,41.59 65.13,41.51 65.13,41.34 65,41.22 64.62,41.22 64.37,40.96 64.05,40.96 63.86,40.77 63.82,40.77 v3(63.6,40.55) ; U24.P7 47.53,41.53 47.05,41.53 46.93,41.4 46.93,41.01 46.84,40.92 46.31,40.92 46.29,40.9 45.52,40.9 45.43,40.81 45.43,40.68 45.63,40.48 45.76,40.48 v3(45.8,40.52) ; v1(63.59,61.39) 63.99,60.99 63.99,59.65 63.89,59.55 63.31,59.55 63.21,59.46 63.21,59.31 63.35,59.17 63.35,59.06 63.13,58.84 62.34,58.84 62.25,58.92 62.25,59.27 62.17,59.35 61.93,59.35 61.84,59.26 61.84,58.82 62.17,58.49 62.62,58.49 62.76,58.35
  TOP w0.117: R1051.2 56.11,39.94 56.05,40 v1(56.05,40.69) 56.37,40.69 56.45,40.77 56.45,41.01 56.29,41.18 56.04,41.18 55.76,41.46 55.09,41.46 54.93,41.29 54.57,41.29 54.36,41.5 54.36,41.92 54.54,42.09 54.54,42.74 54.13,43.15 54.13,44.66 53.47,45.32 53.47,48.99 53.47,49.92 54.14,50.58 54.14,51.91 53.82,52.22 53.59,52.22 53.47,52.35 53.47,52.6 52.41,53.65 52.41,54.37 53.21,55.17 55.27,55.17 55.83,55.73 55.93,55.73 56.22,56.02 56.48,56.02 56.92,55.58 57.86,55.58 57.92,55.51 58.57,55.51 58.76,55.33 58.91,55.33 59.03,55.44 59.03,55.67 59.15,55.79 59.41,55.79 59.53,55.67 59.53,55.29 59.66,55.16 60.8,55.16 61.93,56.29 61.93,56.52 62.05,56.65 62.29,56.65 62.75,57.11 62.75,57.28 62.6,57.44 62.6,57.61 62.76,57.77 62.76,58.35
  IN2 w0.102: v3(45.8,40.52) 45.62,40.69 45.62,40.93 45.73,41.03 46.1,41.03 46.18,40.96 47.63,40.96 48.46,40.12 49.13,40.12 49.33,39.93 49.47,39.93 49.72,40.17 49.89,40.17 50.16,39.89 50.36,39.89 50.62,40.15 51.97,40.15 52.63,40.81 52.82,40.81 52.96,40.66 53.21,40.66 53.35,40.81 53.63,40.81 53.78,40.66 54.02,40.66 54.17,40.81 54.52,40.81 55,41.29 55.45,41.29 v1(56.05,40.69) 55.83,40.48 55.83,40.24 56.33,39.74 56.62,39.74 56.78,39.91 56.78,40.74 56.88,40.84 57.08,40.84 57.19,40.72 57.19,39.85 57.29,39.75 58.09,39.75 58.2,39.85 58.2,40 58.3,40.1 58.5,40.1 58.61,39.99 58.61,39.85 58.71,39.75 58.91,39.75 59.02,39.85 59.02,39.92 59.22,40.12 59.42,40.12 59.81,39.73 61.48,39.73 61.75,40 61.75,40.62 61.91,40.78 62.12,40.78 62.22,40.68 62.22,40.51 62.32,40.41 62.53,40.41 62.63,40.51 62.63,40.68 62.73,40.78 63.37,40.78 v3(63.6,40.55)
  BOTTOM w0.089: v3(45.8,40.52) 45.8,40.21 45.66,40.07 45.53,40.07 45.44,40.16 45.44,40.3 45.25,40.48 45.25,40.81 45.31,40.87 45.57,40.87 45.66,40.96 45.66,41.12 45.57,41.21 45.37,41.21 45.36,41.21 45.05,41.21 44.81,41.46 44.81,41.53 U31.P7 ; v1(63.59,61.39) U7.BC42 ; v3(63.6,40.55) 63.6,40.29 63.51,40.2 63.25,40.2 63.16,40.29 63.16,40.43 63.01,40.57 63.01,40.83 63.12,40.94 63.12,41.77 62.98,41.9 62.86,41.9 62.68,41.73 62.68,41.63 62.59,41.54 62.47,41.54 62.35,41.66 U32.P7
M_A_A2: length 65.6
  TOP w0.089: U24.P3 44.57,41.7 45.16,41.1 45.16,40.63 45.4,40.39 45.4,40.36 45.62,40.14 46.02,40.14 v3(46.43,40.55) ; U25.P3 62.75,41.37 62.75,41.37 63.18,40.93 63.18,40.36 63.42,40.12 63.78,40.12 63.92,40.26 63.92,40.27 v3(64.21,40.55)
  IN1 w0.135: v1(55.77,54.22) 55.77,53.69 54.25,52.17 54.25,50.48 53.47,49.69 53.47,49.68 53.47,45.68 54.31,44.84 54.31,44.19 55.14,43.36 55.14,42.78 55.74,42.18 56.56,42.18 56.9,41.84 56.9,40.81 57.37,40.34 57.37,38.45 57.21,38.29 56.78,38.29 56.55,38.52 56.55,39.51 v1(55.18,40.88)
  IN2 w0.102: v3(46.43,40.55) 46.63,40.75 47.55,40.75 47.83,40.47 47.83,40.21 48.74,39.31 49.98,39.31 50.1,39.44 50.42,39.44 50.57,39.28 50.91,39.28 51.14,39.52 51.14,39.56 51.51,39.93 52.04,39.93 52.53,40.42 54.42,40.42 54.51,40.5 54.8,40.5 v1(55.18,40.88) 55.18,40.45 55.8,39.83 55.87,39.83 56.18,39.52 61.56,39.52 62.16,40.12 63.78,40.12 v3(64.21,40.55)
  BOTTOM w0.089: U7.BJ48 61.31,58.48 61.31,57.62 61.06,57.37 60.14,57.37 59.6,56.84 59.6,55.79 59.42,55.61 57.1,55.61 56.66,55.17 56.66,54.54 56.32,54.19 55.8,54.19 v1(55.77,54.22) ; v3(46.43,40.55) 46.32,40.55 46.04,40.83 46.04,40.96 46.13,41.05 46.3,41.05 46.37,40.98 47.04,40.98 47.13,41.07 47.13,41.44 47.22,41.53 47.53,41.53 U31.P3 ; U32.P3 65.25,41.47 65.05,41.47 64.96,41.56 64.96,41.72 64.92,41.77 64.71,41.77 64.63,41.68 64.63,41.25 64.41,41.03 64.03,41.03 63.92,40.93 63.92,40.83 v3(64.21,40.55)
  BOTTOM w0.117: R1053.2 55.37,40.69 v1(55.18,40.88)
M_A_A3: length 71.3
  TOP w0.089: v3(46.55,41.37) 46.49,41.37 46.21,41.09 45.7,41.09 45.6,41.19 45.6,41.73 45.37,41.96 44.85,41.96 44.59,42.21 44.02,42.21 43.77,42.47 U24.N2 ; v3(64.25,41.41) 64.23,41.41 63.78,40.96 63.44,40.96 63.2,41.21 63.2,41.55 62.61,42.14 61.98,42.14 61.79,42.32 U25.N2
  TOP w0.117: R1058.2 58.82,38.42 58.15,39.09 v1(58.15,40.91)
  IN1 w0.135: v1(58.15,40.91) 57.87,40.91 57.56,41.22 57.56,42.49 56.13,43.92 55.52,43.92 54.97,44.47 54.97,45.3 54.13,46.14 54.13,49.41 54.92,50.19 54.92,51.21 55.72,52.01 v1(55.82,52.01)
  IN2 w0.102: v3(46.55,41.37) 46.76,41.16 47.74,41.16 48.55,40.35 49.55,40.35 49.58,40.38 50.08,40.38 50.11,40.35 51.89,40.35 52.55,41.01 54.39,41.01 54.87,41.49 55.63,41.49 56.02,41.1 57.96,41.1 v1(58.15,40.91) 57.98,40.73 57.52,40.73 57.44,40.65 57.44,40.42 57.53,40.32 58.51,40.32 58.61,40.43 58.61,40.79 58.71,40.89 59.02,40.89 59.12,40.79 59.12,40.45 59.25,40.32 59.5,40.32 59.88,39.94 60.41,39.94 60.52,40.05 60.52,40.27 60.57,40.32 60.83,40.32 61.02,40.13 61.02,40.03 61.13,39.93 61.39,39.93 61.55,40.09 61.55,40.85 61.69,40.99 64.42,40.99 64.65,41.21 65.09,41.21 65.19,41.32 65.19,41.49 65.09,41.59 64.44,41.59 v3(64.25,41.41)
  BOTTOM w0.089: v3(46.55,41.37) 46.52,41.4 46.52,41.65 46.59,41.72 47.26,41.72 47.66,42.12 47.94,42.12 48.14,42.31 48.14,42.9 48.29,43.06 48.42,43.06 48.57,42.91 U31.N2 ; U32.N2 66.35,42.91 66.19,43.06 66.07,43.06 65.92,42.9 65.92,42.2 65.83,42.12 65.39,42.12 65.25,41.98 64.57,41.98 64.25,41.66 v3(64.25,41.41) ; v1(55.82,52.01) 55.82,52.79 55.77,52.84 55.77,53.53 56.18,53.95 56.42,53.95 57.08,54.61 57.08,55.24 57.23,55.39 60.83,55.39 61.24,55.8 61.24,57.07 62.11,57.94 62.11,58.83 62,58.94 62,58.94 61.92,59.02 61.64,59.02 61.55,59.11 U7.BH47
M_A_A4: length 84
  TOP w0.089: v1(63.59,60.68) 63.18,60.28 63.18,59.8 62.92,59.54 62.92,59.23 62.82,59.14 62.6,59.14 62.51,59.22 62.51,59.45 62.39,59.58 61.86,59.58 61.63,59.34 61.63,58.75 62.1,58.28 62.4,58.28 62.51,58.17 62.51,57.88 62.41,57.79 62.28,57.79 ; U25.P8 66.35,41.6 66.09,41.34 65.46,41.34 65.41,41.29 65.41,41.29 65.22,41.1 65.19,41.07 65.19,40.68 64.66,40.15 64.08,40.15 63.83,39.9 63.8,39.9 v3(63.62,39.72) ; U24.P8 48.15,41.35 47.7,41.35 47.15,40.81 47.15,40.68 46.59,40.12 46.27,40.12 45.87,39.72 v3(45.8,39.72)
  TOP w0.117: 62.28,57.79 62.17,57.67 62.17,57.48 62.35,57.3 62.35,57.1 62.19,56.95 62.01,56.95 61.68,57.28 61.5,57.28 61.34,57.12 61.34,56.9 61.65,56.59 61.65,56.4 60.68,55.44 59.92,55.44 59.82,55.54 59.82,55.79 59.53,56.07 59.53,56.19 59.45,56.28 58.99,56.28 58.87,56.15 58.87,56.08 58.57,55.79 58.04,55.79 57.91,55.92 57.44,55.92 57.43,55.92 56.97,55.92 56.59,56.3 56.1,56.3 55.81,56.01 55.72,56.01 55.15,55.45 53.03,55.45 52.13,54.55 52.13,53.54 53.19,52.48 53.19,52.1 53.34,51.95 53.54,51.95 53.8,51.68 53.8,50.74 53.5,50.45 53.32,50.45 53.19,50.32 53.19,50.03 53.19,45.21 53.85,44.55 53.85,42.95 54.26,42.54 54.26,42.21 54.09,42.04 54.09,41.27 54.34,41.02 54.6,41.02 54.76,40.87 54.76,40.68 54.66,40.58 54.26,40.58 54.13,40.45 54.13,39.6 54.26,39.48 54.68,39.48 54.84,39.32 55.02,39.32 55.14,39.45 55.14,39.63 v1(54.67,40.1) 55.13,40.1 55.46,39.76 55.46,39.3 55.68,39.08 55.77,39.08 55.78,39.08 55.91,39.08 R1050.2
  IN2 w0.102: v3(63.62,39.72) 62.58,39.72 61.53,38.67 61.1,38.67 60.99,38.78 60.99,39.08 60.89,39.18 60.69,39.18 60.59,39.08 60.59,38.89 60.49,38.79 60.21,38.79 60.11,38.89 60.11,39.21 60.01,39.31 59.08,39.31 58.87,39.1 58.87,38.88 58.77,38.78 58.57,38.78 58.47,38.88 58.47,39.1 58.37,39.2 58.16,39.2 58.06,39.1 58.06,38.88 57.96,38.78 57.76,38.78 57.65,38.88 57.65,39.1 57.55,39.2 57.35,39.2 57.25,39.1 57.25,38.88 57.12,38.75 56.97,38.75 56.84,38.88 56.84,39.1 56.74,39.2 56.21,39.2 55.79,39.63 55.14,39.63 v1(54.67,40.1) 54.22,39.64 54,39.64 53.9,39.74 53.9,40.1 53.8,40.2 53.6,40.2 53.49,40.1 53.49,39.74 53.39,39.64 53.19,39.64 53.09,39.74 53.09,40.1 52.99,40.2 52.78,40.2 52.68,40.1 52.68,39.74 52.58,39.64 51.6,39.64 51.04,39.08 48.68,39.08 47.82,39.94 47.67,39.94 47.57,40.05 47.57,40.45 47.46,40.55 47.26,40.55 47.16,40.45 47.16,40.05 47.06,39.94 46.85,39.94 46.67,40.12 46.21,40.12 v3(45.8,39.72)
  BOTTOM w0.089: v1(63.59,60.68) 63.78,60.82 U7.BD42 ; v3(45.8,39.72) 45.5,39.72 45.25,39.97 45.25,40.22 44.91,40.55 44.91,41.07 44.67,41.32 44.54,41.32 44.39,41.47 44.32,41.53 44.2,41.53 43.98,41.32 43.88,41.32 43.77,41.43 U31.P8 ; U32.P8 61.55,41.43 61.63,41.34 62.5,41.34 62.75,41.09 62.75,40.56 62.88,40.43 62.88,39.87 63.23,39.51 63.41,39.51 v3(63.62,39.72)
M_A_A5: length 75.2
  TOP w0.089: v3(46.48,39.72) 46.07,39.31 45.59,39.31 45.14,39.76 45.14,40.38 44.91,40.61 44.91,41.09 44.67,41.33 44.21,41.33 U24.P2 ; v3(64.26,39.72) 63.86,39.32 63.3,39.32 62.99,39.63 62.99,40.8 62.46,41.33 61.99,41.33 U25.P2
  TOP w0.117: v1(60.91,58.1) 60.61,58.41 60.36,58.41 60.22,58.55 59.94,58.55 59.83,58.65 59.83,58.82 59.71,58.95 59.45,58.95 59.32,58.82 59.32,58.65 59.2,58.53 59,58.53 58.2,57.73 57.47,57.73 56.99,57.24 56.25,57.24 55.58,56.57 55.49,56.57 54.92,56 52.71,56 51.55,54.84 51.55,53.33 52.63,52.25 52.63,50.26 52.63,44.98 53.29,44.32 53.29,42.29 53.4,42.18 53.64,41.94 53.64,41.94 53.81,41.77 53.81,41.16 54.04,40.93 54.04,40.75 53.85,40.57 53.85,39.49 53.89,39.45 53.89,38.98 54,38.87 54,38.56 54.33,38.23 54.58,38.23 55.09,37.71 55.77,37.71 55.93,37.87 55.93,38.6 55.72,38.81 55.48,38.81 55.31,38.64 55.09,38.64 54.92,38.81 54.75,38.81 v1(54.51,39.05)
  IN2 w0.102: v3(46.48,39.72) 46.8,39.72 47.07,39.44 47.07,39.23 47.17,39.13 47.43,39.13 47.53,39.23 47.53,39.44 47.63,39.54 47.84,39.54 47.94,39.44 47.94,39.23 48.04,39.13 48.2,39.13 48.45,38.88 49.33,38.88 49.43,38.78 49.43,38.57 49.53,38.47 49.73,38.47 49.84,38.57 49.84,38.78 49.94,38.88 50.14,38.88 50.24,38.78 50.24,38.57 50.34,38.47 50.55,38.47 50.65,38.57 50.65,38.73 50.75,38.83 51.07,38.83 51.68,39.44 54.13,39.44 v1(54.51,39.05) 56.08,39.05 56.71,38.42 61.68,38.42 62.58,39.31 63.44,39.31 63.45,39.31 63.85,39.31 v3(64.26,39.72)
  BOTTOM w0.089: v3(64.26,39.72) 64.01,39.97 64.01,40.11 64.07,40.18 64.45,40.18 64.73,40.46 64.96,40.46 64.98,40.48 64.99,40.48 65.2,40.69 65.2,41.11 65.37,41.29 65.77,41.29 65.9,41.42 65.9,41.85 66.11,42.06 66.26,42.06 66.35,41.98 U32.P2 ; U7.BH48 60.77,59.09 60.77,58.83 60.77,58.55 60.91,58.41 v1(60.91,58.1) ; U31.P2 48.12,41.33 47.67,41.33 47.67,41.32 47.62,41.32 47.42,41.11 47.42,40.84 47.35,40.77 47.1,40.77 47.08,40.79 46.93,40.79 46.83,40.69 46.83,40.54 47.01,40.35 47.01,40.2 46.93,40.11 46.6,40.11 46.55,40.15 46.28,40.15 46.17,40.04 46.17,39.81 46.26,39.72 v3(46.48,39.72)
  BOTTOM w0.117: v1(54.51,39.05) 54.97,39.05 55,39.02 R1056.2
M_A_A6: length 75.7
  TOP w0.089: U25.R8 65.96,40.58 65.96,39.11 65.6,38.76 64.5,37.66 64.14,37.66 63.72,37.24 v3(63.64,37.24) ; U24.R8 48.18,40.58 48.18,39.15 46.56,37.53 46.31,37.53 45.99,37.21 v3(45.86,37.21)
  TOP w0.117: R1052.2 56.51,36.45 v1(56.05,36.92)
  IN1 w0.089: v1(61.84,61.7) 62.31,61.7 62.42,61.81 62.75,61.81 63,61.57 63,61.57 63.01,61.56 63.01,59.82 62.76,59.58
  IN1 w0.102: 60.23,57.67 60.5,57.95 60.5,58.27 60.74,58.51 61.41,58.51 61.87,58.97 62.15,58.97 62.76,59.58
  IN1 w0.135: 60.23,57.67 60.08,57.52 59.93,57.52 57.98,55.56 56.33,55.56 53.89,53.12 53.89,50.61 53.14,49.86 53.14,49.82 53.14,45.54 53.98,44.7 53.98,43.95 54.04,43.89 54.04,43.23 54.59,42.68 54.59,40.84 54.73,40.7 56.05,39.38 v1(56.05,36.92)
  IN2 w0.102: v3(63.64,37.24) 63.3,37.24 62.78,36.72 59.48,36.72 59.38,36.82 59.38,37.05 59.28,37.15 59.07,37.15 58.97,37.05 58.97,36.82 58.87,36.72 58.67,36.72 58.57,36.82 58.57,37.05 58.46,37.15 58.26,37.15 58.16,37.05 58.16,36.82 58.06,36.72 57.85,36.72 57.75,36.82 57.75,37.05 57.65,37.15 57.45,37.15 57.35,37.05 57.35,36.82 57.24,36.72 57.04,36.72 56.94,36.82 56.94,37.05 56.84,37.15 56.63,37.15 56.53,37.05 56.53,36.82 56.43,36.72 56.25,36.72 v1(56.05,36.92) 47.42,36.92 46.78,37.56 46.21,37.56 v3(45.86,37.21)
  BOTTOM w0.089: U31.R8 43.77,40.67 44.12,40.31 44.12,38.53 44.31,38.34 44.63,38.34 44.73,38.24 44.73,37.87 44.87,37.73 45.33,37.73 v3(45.86,37.21) ; v3(63.64,37.24) 63.64,37.35 63.08,37.9 63,37.99 63,38.13 63.12,38.26 63.12,38.4 63.02,38.51 62.87,38.51 62.75,38.38 62.6,38.38 61.9,39.08 61.9,40.61 61.82,40.69 U32.R8 ; U7.BB46 v1(61.84,61.7)
M_A_A7: length 81.3
  TOP w0.089: U25.R2 61.9,40.61 61.9,38.35 62.72,37.54 63.42,36.84 63.88,36.84 64.06,37.02 64.07,37.02 64.3,37.25 v3(64.34,37.25) ; v1(46.62,37.15) 46.44,37.15 46.13,36.83 45.08,36.83 44.12,37.79 44.12,40.61 U24.R2
  TOP w0.117: R1057.2 52.88,35.99 52.9,36.01 v1(52.9,36.51)
  IN1 w0.089: 61.77,59.56 61.81,59.59 v1(61.81,60.31)
  IN1 w0.102: 61.77,59.56 61.23,59.02 59.97,59.02 59.83,58.88 59.47,58.88 59.03,58.43 58.79,58.2 58.79,57.93 58.77,57.91
  IN1 w0.135: 58.77,57.91 57.14,56.28 56.44,56.28 56.07,56.28 52.86,53.07 52.86,52.9 52.55,52.59 52.55,50.92 52.15,50.52 52.15,50.23 52.15,47.32 51.85,47.03 51.85,45.42 52.99,44.29 52.99,43.54 53.04,43.48 53.04,42.86 53.01,42.82 53.01,40.5 52.64,40.13 52.03,40.13 51.85,39.95 51.85,39.6 52.03,39.42 52.83,39.42 53.05,39.2 53.05,38.35 52.9,38.19 v1(52.9,36.51)
  IN2 w0.102: v1(46.62,37.15) 47.15,36.62 47.15,36.37 47.71,35.8 48.2,35.8 48.3,35.91 48.3,36.36 48.4,36.46 48.6,36.46 48.71,36.36 48.71,35.91 48.81,35.8 49.01,35.8 49.11,35.91 49.11,36.36 49.21,36.46 49.42,36.46 49.52,36.36 49.52,35.91 49.62,35.8 49.82,35.8 49.92,35.91 49.92,36.36 50.03,36.46 50.23,36.46 50.33,36.36 50.33,35.91 50.43,35.8 50.64,35.8 50.74,35.91 50.74,36.36 50.84,36.46 51.04,36.46 51.14,36.36 51.14,35.91 51.25,35.8 51.45,35.8 51.93,36.29 52.67,36.29 v1(52.9,36.51) 63.08,36.51 63.4,36.83 63.92,36.83 v3(64.34,37.25)
  BOTTOM w0.089: U32.R2 66.25,41.07 66.23,41.09 65.98,41.09 65.88,40.99 65.88,40.04 66.12,39.8 66.12,38.63 65.78,38.28 65.65,38.28 65.54,38.39 65.4,38.39 65.29,38.28 65.29,38.14 65.43,38 65.43,37.82 65.32,37.71 64.94,37.71 64.7,37.47 64.56,37.47 v3(64.34,37.25) ; v1(46.62,37.15) 46.38,37.15 46.29,37.24 46.29,37.48 46.44,37.63 47.18,37.63 47.26,37.56 47.44,37.56 47.55,37.68 47.55,37.88 47.41,38.02 47.41,38.19 47.62,38.39 47.77,38.39 47.87,38.29 48.01,38.29 48.35,38.63 48.35,39.45 48.21,39.58 48.21,40.61 U31.R2 ; U7.BE46 v1(61.81,60.31)
M_A_A8: length 77.4
  TOP w0.089: v3(63.59,36.45) 63.76,36.45 63.98,36.67 63.98,36.67 64.14,36.83 64.47,36.83 64.47,36.83 65.15,36.83 65.2,36.88 65.2,36.88 65.44,37.11 65.44,38.12 65.56,38.24 66.03,38.24 66.35,38.55 U25.T8 ; U24.T8 48.57,39.16 47.12,37.71 47.12,37.11 46.74,36.74 46.38,36.74 46,36.35 v1(45.75,36.35)
  TOP w0.117: v1(53.83,35.79) 54.18,35.44 R1065.2
  IN1 w0.089: v1(62.6,60.69) 62.43,60.69 62.25,60.51 62.25,60.2 62.2,60.15 62.2,59.61 62.04,59.45
  IN1 w0.102: 59.12,57.47 59.27,57.62 59.36,57.62 59.63,57.89 59.63,58.37 59.77,58.51 60.06,58.51 60.31,58.77 61.36,58.77 62.04,59.45
  IN1 w0.135: v1(53.83,35.79) 53.83,36.47 53.23,37.07 53.23,37.71 54.03,38.52 54.03,38.97 53.85,39.14 53.65,39.14 53.03,39.75 53.03,40.01 53.65,40.63 53.65,41.6 53.34,41.92 53.34,42.69 53.37,42.72 53.37,43.62 53.32,43.67 53.32,44.43 52.19,45.56 52.19,46.89 52.48,47.18 52.48,48.72 52.48,50.38 52.88,50.78 52.88,52.14 53.05,52.32 53.3,52.32 53.48,52.5 53.48,53.22 56.2,55.95 57.6,55.95 59.12,57.47
  IN2 w0.102: v3(63.59,36.45) 63.37,36.23 54.27,36.23 v1(53.83,35.79) 53.63,35.6 53.29,35.6 53.19,35.7 53.19,35.91 53.08,36.01 52.88,36.01 52.78,35.91 52.78,35.7 52.68,35.6 52.48,35.6 52.37,35.7 52.37,35.91 52.27,36.01 52.07,36.01 51.97,35.91 51.97,35.7 51.87,35.6 47.55,35.6 46.93,36.23 46.93,36.49 46.69,36.73 46.13,36.73 v1(45.75,36.35)
  BOTTOM w0.089: v1(62.6,60.69) 62.89,60.9 U7.BD44 ; v3(63.59,36.45) 62.84,37.21 62.84,37.35 62.95,37.46 62.95,37.61 62.87,37.69 62.84,37.71 62.69,37.71 62.54,37.56 62.4,37.56 62.29,37.67 62.29,37.82 62.45,37.97 62.45,38.11 62.35,38.21 62.19,38.21 62.04,38.07 61.91,38.07 61.81,38.17 61.81,38.29 61.93,38.41 61.93,38.64 61.54,39.02 61.54,40.17 U32.T8 ; U31.T8 43.77,38.15 43.92,37.99 44.05,37.99 44.18,38.12 44.31,38.12 44.43,37.99 44.43,37.87 44.3,37.74 44.3,37.61 45.01,36.9 45.2,36.9 v1(45.75,36.35)
M_A_A9: length 72.2
  TOP w0.089: v3(64.27,38.89) 64.06,38.68 64.01,38.68 63.81,38.48 63.25,38.48 62.74,38.99 62.74,40.33 62.57,40.5 62.28,40.5 62.2,40.59 62.2,40.82 U25.R3 ; v3(46.49,38.89) 46.45,38.89 46.08,38.52 46.08,38.52 46.03,38.47 45.61,38.47 45.21,38.87 44.96,38.87 44.61,39.22 44.61,39.75 44.7,39.84 44.7,39.84 44.89,40.03 44.89,40.31 44.57,40.63 U24.R3
  TOP w0.117: v1(56.82,57.76) 56.58,57.52 56.37,57.52 56.14,57.52 55.46,56.85 55.37,56.85 54.81,56.28 52.59,56.28 51.27,54.97 51.27,53.17 52.33,52.1 52.33,44.88 53.01,44.2 53.01,42.17 53.12,42.07 53.12,42.07 53.54,41.64 53.54,41.05 53.58,41.01 v1(53.58,38.7)
  IN2 w0.102: v3(46.49,38.89) 46.7,38.67 47.94,38.67 48.2,38.42 48.6,38.42 48.7,38.32 48.7,37.92 48.96,37.66 50.54,37.66 50.65,37.76 50.65,37.91 50.75,38.01 50.95,38.01 51.05,37.91 51.05,37.76 51.15,37.66 51.65,37.66 51.75,37.76 51.75,38.17 51.88,38.29 52.06,38.29 52.16,38.19 52.16,37.76 52.26,37.66 52.46,37.66 52.57,37.76 52.57,38.19 52.67,38.29 52.87,38.29 52.97,38.19 52.97,37.76 53.07,37.66 53.43,37.66 53.53,37.76 53.53,38.65 v1(53.58,38.7) 53.84,38.44 54.99,38.44 55.07,38.52 55.72,38.52 56.22,38.01 62.28,38.01 62.74,38.47 63.85,38.47 v3(64.27,38.89)
  BOTTOM w0.089: U7.BE52 58.77,60.87 58.41,60.87 58.13,60.59 57.79,60.59 56.43,59.22 56.43,58.97 55.74,58.28 55.33,58.28 55.16,58.1 55.16,57.85 55.25,57.76 v1(56.82,57.76) ; v3(64.27,38.89) 64.27,38.51 64.35,38.43 64.7,38.43 65.31,39.05 65.31,39.56 65.18,39.69 64.92,39.69 64.83,39.78 64.83,40.07 64.94,40.17 65.06,40.17 65.2,40.31 65.2,40.31 65.55,40.66 U32.R3 ; U31.R3 47.99,40.75 47.99,40.59 47.89,40.5 47.48,40.5 47.28,40.3 47.28,40.02 47.53,39.77 47.53,39.62 47.43,39.52 47.28,39.52 47.14,39.66 46.96,39.66 46.83,39.52 46.83,39.34 47.06,39.12 47.06,38.94 46.87,38.75 46.63,38.75 v3(46.49,38.89)
  BOTTOM w0.117: v1(53.58,38.7) 53.39,38.51 R1072.2
M_A_A10: length 63.2
  TOP w0.089: v3(64.12,44.47) 64.33,44.47 64.55,44.26 64.55,44.08 64.64,43.99 64.95,43.99 64.97,43.97 65.25,43.69 65.95,43.69 66.05,43.78 66.05,44.02 65.9,44.17 U25.L7 ; U24.L7 47.76,44.17 47.39,44.17 46.86,44.7 46.24,44.7 46.17,44.62 45.25,44.62 v3(45.06,44.44)
  IN1 w0.135: v1(56.42,52.36) 56.42,51.98 56.26,51.82 55.27,50.83 55.27,50.01 54.48,49.23 54.48,46.25 55.89,44.84 55.89,44.62 57.96,42.55 58.26,42.55 58.44,42.73 58.44,43 v1(56.5,44.94)
  IN2 w0.102: v3(64.12,44.47) 64.52,44.47 64.63,44.36 65.03,44.36 65.13,44.26 65.13,44.12 65.03,44.02 64.48,44.02 64.41,44.09 64.09,44.09 64.07,44.07 63.47,44.07 63.02,44.52 62.77,44.52 62.36,44.11 62.17,44.11 62.02,43.96 61.58,43.96 61.43,44.11 61.05,44.11 60.9,43.96 60.31,43.96 60.15,44.11 59.96,44.11 59.74,44.33 58.93,44.33 58.66,44.07 58.66,43.83 58.56,43.73 57.54,43.73 57.14,44.14 56.84,44.14 56.5,44.47 v1(56.5,44.94) 56.33,45.1 54.25,45.1 54.2,45.15 52.01,45.15 51.29,44.44 51.04,44.44 50.58,43.98 47.58,43.98 47.48,44.09 46.89,44.09 46.73,43.92 46.41,43.92 46.36,43.97 46.19,44.15 46.19,44.17 45.96,44.4 45.1,44.4 v3(45.06,44.44)
  BOTTOM w0.089: U32.L7 62.5,44.01 62.66,44.01 62.75,44.11 62.75,44.54 62.96,44.75 63.1,44.75 63.16,44.69 63.16,44.3 63.3,44.16 63.72,44.16 64.03,44.47 v3(64.12,44.47) ; U7.BJ45 62.56,58.59 62.56,58.34 62.47,58.24 62.47,57.79 61.66,56.98 61.66,55.5 60.97,54.81 60.97,54.8 60.73,54.57 60.73,54.57 60.71,54.55 59.57,54.55 59.2,54.18 59.02,54.18 58.82,53.98 58.82,53.8 58.14,53.12 56.85,53.12 56.42,52.69 v1(56.42,52.36) ; U31.L7 44.56,44.17 44.24,44.17 43.93,43.86 43.93,43.7 44.07,43.55 44.28,43.55 44.42,43.69 44.62,43.69 44.79,43.86 45.06,43.86 45.29,44.09 45.29,44.21 v3(45.06,44.44)
  BOTTOM w0.117: v1(56.5,44.94) 56.18,45.26 R1071.2
M_A_A11: length 72.4
  TOP w0.089: v3(63.64,38.88) 63.67,38.91 63.76,38.91 64.16,39.31 64.42,39.31 64.74,39.62 65.17,40.06 65.17,40.27 65.55,40.64 U25.R7 ; v3(45.85,38.88) 45.91,38.88 46.31,39.28 46.8,39.28 47.39,39.87 47.39,40.59 U24.R7
  IN1 w0.102: 58.19,61.47 59.23,61.47 59.43,61.27 59.99,61.27 v1(60.41,61.7)
  IN1 w0.135: 58.19,61.47 57.82,61.47 57.11,60.76 57.11,59.19 57.28,59.03 57.28,58.66 57.02,58.4 56.07,58.4 55.07,57.4 55.07,56.84 54.61,56.39 53.68,56.39 51.99,54.7 51.99,54.27 51.55,53.82 51.55,51.32 51.16,50.93 51.16,50.63 51.16,48.99 50.57,48.41 50.57,46.68 50.47,46.58 50.47,45.69 49.96,45.18 49.96,43.83 50.23,43.56 51.62,43.56 51.8,43.39 51.8,42.55 51.4,42.15 51.4,40.75 51.52,40.62 51.52,39.46 51.8,39.18 51.8,38.91 v1(51.98,38.72)
  IN2 w0.102: v3(63.64,38.88) 62.57,38.88 61.91,38.22 56.4,38.22 55.83,38.78 54.9,38.78 54.76,38.64 54.34,38.64 53.87,39.11 52.36,39.11 v1(51.98,38.72) 51.98,39.01 51.88,39.11 51.68,39.11 51.5,38.93 51.5,38.39 51.55,38.34 51.55,38.11 51.47,38.04 51.21,38.04 51.01,38.24 50.05,38.24 49.95,38.14 49.95,37.99 49.85,37.89 49.64,37.89 49.54,37.99 49.54,38.14 49.44,38.24 49.11,38.24 48.96,38.39 48.96,38.55 48.83,38.67 48.32,38.67 48.07,38.93 46.97,38.93 46.87,39.03 46.87,39.21 46.77,39.31 45.63,39.31 45.2,39.74 44.84,39.74 44.62,39.52 44.62,38.78 44.74,38.65 44.91,38.65 45.07,38.81 45.21,38.81 45.51,38.51 45.71,38.51 45.85,38.65 v3(45.85,38.88)
  BOTTOM w0.089: v3(45.85,38.88) 45.47,38.88 45.37,38.98 45.37,39.52 45.06,39.83 45.06,40.14 44.73,40.47 44.72,40.47 44.7,40.49 44.43,40.49 44.34,40.58 44.34,40.74 U31.R7 ; U7.BB49 v1(60.41,61.7) ; v3(63.64,38.88) 63.64,38.9 63.35,39.18 63.18,39.18 62.68,39.69 62.68,40.33 62.42,40.58 62.25,40.58 62.08,40.75 62.08,40.88 62.17,40.97 62.34,40.97 U32.R7
  BOTTOM w0.117: v1(51.98,38.72) 51.92,38.66 R1066.2
M_A_A12: length 69.1
  TOP w0.089: 61.44,57.64 61.44,57.76 61.31,57.9 61.31,58.42 61.23,58.5 61.08,58.5 60.86,58.5 60.78,58.58 60.78,58.73 60.86,58.81 61.11,58.81 61.2,58.9 61.2,59.04 61.13,59.11 60.85,59.11 60.77,59.19 60.77,59.34 60.85,59.42 61.25,59.42 61.33,59.49 v1(61.33,59.74) ; U25.N7 65.39,42.41 65.33,42.41 65.26,42.34 65.12,42.34 65.09,42.31 64.78,42.31 64.48,42.61 64.3,42.61 64.15,42.76 63.66,42.76 63.56,42.66 v3(63.56,42.2) ; v3(45.84,42.28) 45.89,42.28 45.89,42.29 45.97,42.29 46.21,42.53 46.81,42.53 46.93,42.65 46.93,42.69 47.02,42.77 47.38,42.77 47.53,42.93 48.11,42.93 48.2,42.84 48.2,42.66 48.11,42.57 U24.N7
  TOP w0.117: v1(53.81,42.36) 53.57,42.6 53.57,44.43 52.91,45.09 52.91,48.76 52.91,52.37 51.83,53.45 51.83,54.73 52.83,55.72 55.04,55.72 55.6,56.29 55.69,56.29 56.34,56.94 56.81,56.94 56.94,56.81 56.94,56.35 57.09,56.2 57.32,56.2 57.45,56.33 57.45,57.21 57.62,57.39 57.96,57.39 58.09,57.26 58.09,57.14 58.22,57.02 58.22,56.65 58.09,56.53 58.09,56.2 58.22,56.07 58.46,56.07 58.59,56.2 58.59,56.43 58.72,56.57 59.46,56.57 59.59,56.7 59.59,56.95 59.47,57.07 58.71,57.07 58.59,57.2 58.59,57.44 58.71,57.57 59.5,57.57 59.71,57.36 59.91,57.36 60.32,57.77 60.54,57.77 60.94,57.37 61.18,57.37 61.44,57.64
  IN2 w0.102: v3(63.56,42.2) 63.18,42.2 62.93,41.95 62.59,41.95 62.49,42.05 62.49,42.15 62.39,42.25 62.19,42.25 62.09,42.15 62.09,42.05 61.99,41.95 61.78,41.95 61.68,42.05 61.68,42.15 61.58,42.25 61.38,42.25 61.27,42.15 61.27,42.05 61.17,41.95 60.94,41.95 60.93,41.95 60.72,41.95 60.51,41.75 58.39,41.75 57.9,42.24 57.11,42.24 56.81,42.55 54.48,42.55 54.29,42.36 v1(53.81,42.36) 53.81,41.92 53.71,41.82 53.39,41.82 53.29,41.92 53.29,42.31 53.19,42.41 53.01,42.41 52.88,42.28 52.88,42.17 52.78,42.07 52.52,42.07 52.44,42.15 52.29,42.15 52.05,41.91 51.84,41.91 51.59,42.16 51.43,42.16 51.25,41.98 50.18,41.98 50,41.8 49.72,41.8 49.54,41.98 48.96,41.98 48.83,42.1 48.83,42.27 48.52,42.59 46.2,42.59 46.09,42.69 45.94,42.69 45.84,42.59 v3(45.84,42.28)
  BOTTOM w0.089: U7.BF48 61.32,59.9 v1(61.33,59.74) ; v3(63.56,42.2) 63.56,42.47 63.47,42.57 63.22,42.57 63.13,42.66 63.13,43.16 63.04,43.25 62.86,43.25 62.77,43.16 62.77,42.55 62.64,42.42 62.49,42.42 U32.N7 ; v3(45.84,42.28) 45.84,42.6 45.63,42.81 45.11,42.81 44.9,43.02 44.4,43.02 44.25,43.17 44.12,43.17 43.96,43.01 43.96,42.86 44.13,42.69 44.13,42.58 44.25,42.47 44.47,42.47 U31.N7
  BOTTOM w0.117: v1(53.81,42.36) 54.1,42.64 R1068.2
M_A_A13: length 73.8
  TOP w0.089: v3(64.27,38.06) 63.87,37.66 63.06,37.66 62.17,38.55 62.17,39.64 62.35,39.82 U25.T3 ; U24.T3 44.42,40.02 44.42,38.52 45.27,37.67 46.03,37.67 46.04,37.68 46.17,37.68 v3(46.5,38.01)
  TOP w0.117: R1069.2 54.81,36.94 54.78,36.98 v1(54.78,37.33)
  IN1 w0.135: v1(54.78,37.33) 54.52,37.07 54.52,36.57 54.73,36.36 55.21,36.36 55.53,36.68 55.53,37.03 55.7,37.21 55.7,39.17 55.22,39.65 54.39,39.65 54.04,40.01 54.04,41.59 54.26,41.81 54.26,42.54 53.7,43.1 53.7,43.75 53.65,43.81 53.65,44.56 52.52,45.7 52.52,46.75 52.81,47.04 52.81,48.86 52.81,50 53.33,50.52 v1(53.33,50.87)
  IN2 w0.102: v3(64.27,38.06) 63.84,37.63 63.34,37.63 63.11,37.4 55.64,37.4 55.56,37.33 v1(54.78,37.33) 54.7,37.25 48.18,37.25 48.08,37.35 48.08,37.81 47.98,37.91 47.77,37.91 47.67,37.81 47.67,37.35 47.57,37.25 47.4,37.25 46.88,37.77 46.88,37.91 46.77,38.01 v3(46.5,38.01)
  BOTTOM w0.089: v3(46.5,38.01) 46.48,38.01 46.33,38.16 46.33,38.4 46.42,38.49 46.91,38.49 47.09,38.31 47.19,38.31 47.29,38.41 47.29,38.56 47.2,38.66 47.2,38.81 47.3,38.91 47.45,38.91 47.51,38.85 47.85,38.85 47.94,38.94 47.94,39.18 47.82,39.31 47.82,39.56 47.94,39.69 47.94,39.99 U31.T3 ; v1(53.33,50.87) 53.33,50.52 53.64,50.21 56.67,50.21 57.41,50.94 57.77,50.94 58.03,51.2 58.04,51.2 58.28,51.43 58.28,51.45 60.59,53.76 60.98,53.76 61.04,53.81 61.34,53.81 62.28,54.75 62.28,56.85 63,57.57 63,58.02 63.34,58.36 63.34,58.85 63.44,58.95 63.44,59.19 63.09,59.54 U7.BF44 ; U32.T3 65.34,39.96 65.34,39.82 65.6,39.56 65.76,39.56 65.85,39.47 65.85,38.8 65.72,38.67 65.34,38.67 64.96,38.29 64.96,38.04 64.58,37.66 64.33,37.66 64.27,37.71 v3(64.27,38.06)
