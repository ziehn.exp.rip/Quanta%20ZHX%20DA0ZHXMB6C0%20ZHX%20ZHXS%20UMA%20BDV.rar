# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ25: length 23.8
  TOP w0.094: v3(45.26,53.34) 44.33,53.34 43.77,52.78 43.77,52.17 U24.A2
  IN1 w0.107: v3(45.26,53.34) 45.84,53.92 45.84,54.22 45.73,54.32 45.66,54.32 45.56,54.42 45.56,54.62 45.66,54.72 45.73,54.72 45.84,54.82 45.84,55.34 45.73,55.44 45.45,55.44 45.35,55.55 45.35,56.17 45.67,56.49 45.67,56.67 45.87,56.87 46.05,56.87 46.25,57.07 46.25,57.24 46.44,57.44 46.62,57.44 46.82,57.64 46.82,57.82 47.02,58.02 47.2,58.02 47.4,58.22 47.4,58.4 47.59,58.59 47.77,58.59 48.52,59.35 48.62,59.35 48.86,59.59 48.86,59.68 49.24,60.07 49.24,60.34 49.39,60.49 49.67,60.49 49.82,60.64 49.82,60.92 49.97,61.07 50.25,61.07 50.35,61.17 52.22,61.17 52.51,61.46 52.62,61.46 v1(52.74,61.58)
  BOTTOM w0.094: U7.AV52 58.35,64.18 58.19,64.03 57.19,64.03 57.1,63.94 57.09,63.94 56.75,63.6 56.75,63.59 55.59,62.42 53.58,62.42 v1(52.74,61.58)
M_A_DQ26: length 22.8
  TOP w0.089: U24.C8 48.57,50.57
  TOP w0.094: 48.57,50.57 v3(48.97,50.97)
  IN1 w0.107: v1(54.17,58.54) 54.17,58.01 53.95,57.79 53.78,57.79 53.6,57.97 53.33,57.97 53.13,58.18 52.98,58.18 52.85,58.04 52.85,57.67 52.42,57.25 52.42,56.92 52.16,56.66 51.78,56.66 51.61,56.83 51.46,56.83 51.24,56.6 51.24,56.44 51.45,56.23 51.45,55.98 51.31,55.84 51.09,55.84 50.79,55.54 50.65,55.54 50.33,55.22 50.33,55.07 50.16,54.9 48.91,54.9 48.76,54.75 48.76,54.44 48.63,54.32 48.63,54.19 48.86,53.96 49.1,53.96 49.18,54.05 49.18,54.37 49.29,54.47 50.08,54.47 50.18,54.37 50.18,53.9 49.87,53.59 49.87,53.38 50.12,53.13 50.12,52.99 49.92,52.78 49.92,52.64 50.15,52.41 50.15,52.31 50.05,52.21 49.97,52.21 49.97,52.21 49.65,52.21 49.65,52.21 49.38,51.94 49.38,51.06 49.29,50.97 v3(48.97,50.97)
  BOTTOM w0.094: U7.BC53 57.94,61.88 57.36,61.3 57.36,61.05 56.02,59.7 56.01,59.7 55.27,58.96 55.03,58.96 54.7,58.96 54.68,58.94 54.57,58.94 v1(54.17,58.54)
M_A_DQ27: length 24.5
  TOP w0.094: U24.A3 44.57,52.17 44.57,52.42 44.87,52.72 v3(45.24,52.72)
  IN1 w0.107: v1(52.03,61.58) 51.91,61.46 49.82,61.46 48.57,60.21 48.33,60.21 48.29,60.16 48.28,60.16 48.04,59.93 48.04,59.59 48.04,59.58 48.04,59.45 44.64,56.05 44.64,55.8 44.74,55.7 44.97,55.7 45.07,55.6 45.07,55.4 44.97,55.3 44.74,55.3 44.64,55.2 44.64,52.9 44.82,52.72 v3(45.24,52.72)
  BOTTOM w0.094: v1(52.03,61.58) 53.18,62.73 53.28,62.73 53.3,62.75 55.52,62.75 57.08,64.31 57.77,64.31 57.82,64.26 58.16,64.26 58.22,64.33 58.28,64.38 58.75,64.38 58.85,64.48 59.09,64.48 59.09,64.48 59.39,64.18 U7.AV51
M_A_DQ28: length 24.7
  TOP w0.094: U24.C2 44.18,50.15 44.69,50.15 45.19,50.65 45.19,51.51 45.76,52.09 v3(45.76,52.38)
  IN1 w0.107: v1(54.17,61.58) 53.63,61.05 52.65,61.05 52.42,60.82 52.36,60.76 50.33,60.76 49.14,59.56 49.14,59.47 48.74,59.07 48.64,59.07 46.14,56.57 46.14,53.63 46.33,53.44 46.33,52.94 v3(45.76,52.38)
  BOTTOM w0.094: v1(54.17,61.58) 54.45,61.87 54.45,61.87 54.75,62.17 54.76,62.17 55.65,62.17 55.74,62.26 55.8,62.26 57.02,63.48 57.02,63.49 57.2,63.67 57.21,63.67 57.33,63.79 58.23,63.79 58.42,63.98 58.75,63.98 59.03,63.7 U7.AW51
M_A_DQ29: length 22.9
  TOP w0.094: v3(48.97,51.74) 48.59,51.37 U24.B8
  IN1 w0.107: v3(48.97,51.74) 48.97,51.45 48.86,51.35 48.68,51.35 48.58,51.45 48.58,52.07 48.76,52.25 49.3,52.25 49.57,52.52 49.57,53.49 49.38,53.69 48.74,53.69 48.46,53.97 48.38,53.97 48.27,54.07 48.27,54.36 48.48,54.56 48.48,54.95 48.59,55.07 48.59,55.37 48.67,55.44 48.81,55.44 49.07,55.18 49.38,55.18 49.73,55.54 49.89,55.54 49.98,55.44 50.15,55.44 50.28,55.57 50.28,55.71 50.17,55.82 50.17,55.98 50.29,56.1 50.44,56.1 50.54,55.99 50.71,55.99 50.96,56.24 50.96,56.39 50.89,56.45 50.89,56.87 50.97,56.94 51.19,56.94 51.45,57.2 51.45,57.39 51.57,57.52 51.71,57.52 51.95,57.75 52.1,57.75 52.23,57.62 52.4,57.62 52.53,57.75 52.53,57.9 52.32,58.11 52.32,58.25 52.44,58.37 52.44,58.41 52.57,58.54 v1(52.74,58.54)
  BOTTOM w0.094: v1(52.74,58.54) 53.43,59.22 54.46,59.22 54.58,59.22 54.59,59.24 55.16,59.24 55.89,59.97 55.9,59.97 57.18,61.25 57.18,61.42 57.98,62.22 58.73,62.22 58.79,62.15 58.79,62.15 58.98,61.96 58.98,61.82 U7.BC52
M_A_DQ30: length 22.6
  TOP w0.094: U24.C3 44.91,50.92 44.91,51.82 v3(45.23,52.13)
  IN1 w0.107: v1(54.88,61.58) 53.94,60.64 52.82,60.64 52.65,60.48 50.45,60.48 49.42,59.45 49.42,59.36 46.47,56.41 46.47,53.69 46.6,53.56 46.6,52.57 46.01,51.98 45.38,51.98 v3(45.23,52.13)
  BOTTOM w0.094: U7.AW53 58.38,63.49 57.41,63.49 55.91,61.99 55.86,61.99 55.76,61.9 55.72,61.9 55.41,61.58 v1(54.88,61.58)
M_A_DQ31: length 24.2
  TOP w0.094: v3(48.16,52.63) 48.16,52.62 47.77,52.22 U24.A7
  IN1 w0.107: v3(48.16,52.63) 48.38,52.41 48.53,52.41 48.69,52.58 48.69,52.91 48.57,53.03 48.57,53.47 48.35,53.69 48.12,53.69 47.99,53.81 47.99,54.47 48.2,54.68 48.2,55.06 48.26,55.12 48.26,55.17 48.31,55.22 48.31,55.62 48.48,55.79 48.86,55.79 49.15,55.5 49.3,55.5 49.44,55.64 49.44,55.78 49.27,55.96 49.27,56.1 49.41,56.25 49.55,56.25 49.73,56.07 49.87,56.07 50.02,56.22 50.02,56.36 49.56,56.81 49.56,56.97 49.69,57.1 49.85,57.1 50.2,56.75 50.35,56.75 50.46,56.86 50.46,57.07 50.27,57.26 50.27,57.4 50.41,57.55 50.55,57.55 50.88,57.22 51.02,57.22 51.17,57.37 51.17,57.51 50.7,57.97 50.7,58.1 50.85,58.25 51,58.25 51.45,57.8 51.6,57.8 51.74,57.94 51.74,58.08 51.57,58.26 51.57,58.4 51.7,58.54 v1(52.03,58.54)
  BOTTOM w0.094: v1(52.03,58.54) 52.97,59.48 53.29,59.48 53.31,59.5 54.34,59.5 54.46,59.5 54.47,59.51 54.94,59.51 55.01,59.58 55.05,59.58 55.3,59.83 55.3,59.88 57.87,62.44 58.85,62.44 59.14,62.15 U7.BB51
M_A_DQ32: length 11.9
  BOTTOM w0.089: U7.BG42 64.11,59.49 64.4,59.21 64.4,58.93 64.32,58.86 64.32,58.46 64.39,58.4 64.39,57.71 64.44,57.66
  BOTTOM w0.094: 64.44,57.66 64.5,57.6 64.5,57.37 64.4,57.27 64.04,57.27 63.94,57.17 63.57,57.17 63.12,56.72 63.12,56.45 63.21,56.36 63.49,56.36 63.59,56.25 63.59,56.11 63.49,56 63.2,56 63.11,55.91 63.11,55.73 63.2,55.65 63.31,55.65 63.4,55.56 63.4,55.38 63.31,55.29 63.22,55.29 63.13,55.2 63.13,54.95 63.28,54.8 63.28,53.71 63.21,53.64 62.73,53.64 62.44,53.35 62.44,53.06 62.34,52.95 62.09,52.95 62.01,52.86 62.01,52.75 62.01,52.75 62.01,52.63 61.86,52.49 61.86,52.03 61.55,51.72 U32.B8
M_A_DQ33: length 12.3
  BOTTOM w0.089: 61.22,50.59 61.06,50.75 61.06,51.16 61.06,51.16 61.06,52.37 61.06,52.37 61.06,52.8 60.99,52.86 ; U7.BG43 63.63,59.13 63.91,58.85 63.91,58.37 64.03,58.25 64.03,57.92 63.73,57.62
  BOTTOM w0.094: 63.73,57.62 63.45,57.62 62.7,56.88 62.7,55.1 62.62,55.02 62.62,54.37 61.72,53.47 61.32,53.47 60.99,53.13 60.99,52.86 ; 61.22,50.59 61.22,50.44 61.47,50.19 61.92,50.19 U32.D7
M_A_DQ34: length 13.7
  BOTTOM w0.089: U7.BG37 66.37,59.6 66.29,59.6 66.17,59.48 66.17,59.37 66.34,59.19 66.34,59.08 66.42,59.01 66.69,59.01 66.85,58.84 66.85,58.14 66.66,57.95
  BOTTOM w0.094: 66.66,57.95 66.66,57.77 66.77,57.66 66.77,57.47 66.55,57.25 66.55,55.08 66.45,54.98 65.94,54.98 65.84,54.88 65.84,54.68 65.92,54.6 66.54,54.6 66.64,54.5 66.64,53.84 66.53,53.74 65.47,53.74 65.34,53.61 65.34,52.98 65.67,52.65 65.67,52.51 65.9,52.27 65.9,52.01 65.71,51.81 65.71,51.67 65.92,51.46 65.92,51.3 66.12,51.1 66.12,50.97 65.92,50.76 65.92,50.49 66.02,50.39 66.16,50.39 U32.C2
M_A_DQ35: length 12.1
  BOTTOM w0.089: U7.BJ37 66.31,58.69 66.23,58.61 66.23,58.5 66.37,58.37 66.43,58.37 66.49,58.37 66.58,58.28 66.58,58.17 66.32,57.91 66.32,57.82 66.47,57.66
  BOTTOM w0.094: 66.47,57.66 66.47,57.55 66.19,57.26 66.19,57.15 66.36,56.97 66.36,56.49 66.27,56.39 65.55,56.39 65.42,56.26 65.42,56.09 65.5,56.01 66.27,56.01 66.36,55.92 66.36,55.75 66.11,55.5 66.11,55.24 66.04,55.17 65.82,55.17 65.73,55.26 65.73,55.56 65.64,55.65 65.43,55.65 65.37,55.58 65.37,55.44 65.09,55.16 65.09,55.04 65.18,54.95 65.46,54.95 65.57,54.84 65.57,54.56 65.78,54.35 65.78,54.12 65.69,54.04 65.15,54.04 65.06,53.95 65.06,52.83 65.13,52.76 65.28,52.76 65.47,52.56 65.47,52.39 65.55,52.32 U32.A3
M_A_DQ36: length 10.3
  BOTTOM w0.089: U32.C8 61.24,50.88 61.24,51.24 61.23,51.24 61.23,52.3 61.24,52.3 61.24,52.98 ; 63.8,57.42 64.21,57.83 64.21,58.32 64.11,58.42 U7.BH42
  BOTTOM w0.094: 61.24,52.98 61.44,53.19 61.84,53.19 62.9,54.25 62.9,56.78 63.54,57.42 63.8,57.42
M_A_DQ37: length 10.3
  BOTTOM w0.089: U7.BJ41 64.6,57.78
  BOTTOM w0.094: 64.6,57.78 64.71,57.67 64.71,57.14 64.61,57.05 64.14,57.05 64.05,56.95 63.64,56.95 63.5,56.82 63.5,56.67 63.8,56.38 63.8,56.19 64.07,55.92 64.07,55.77 63.67,55.38 63.67,55.16 63.58,55.06 63.58,53.18 63.46,53.06 63.31,53.06 63.02,53.36 62.87,53.36 62.72,53.21 62.72,53.07 63.03,52.76 63.03,52.61 62.9,52.48 62.72,52.48 62.49,52.71 62.36,52.71 62.17,52.53 62.17,52.34 U32.A7
M_A_DQ38: length 12.4
  BOTTOM w0.089: U7.BH36 67.03,57.85
  BOTTOM w0.094: 67.03,57.85 67.09,57.78 67.28,57.78 67.35,57.71 67.35,57.52 67.28,57.45 67.03,57.45 66.75,57.16 66.75,56.39 66.99,56.15 66.99,55.9 66.83,55.74 66.83,55.5 66.99,55.34 66.99,55.15 66.83,54.98 66.83,54.75 66.92,54.66 66.92,53.69 67.02,53.59 67.41,53.59 67.51,53.69 67.51,53.79 67.68,53.96 67.83,53.96 67.93,53.86 67.93,53.28 67.81,53.16 66.75,53.16 66.46,53.46 66.29,53.46 66.16,53.33 66.01,53.33 65.88,53.46 65.72,53.46 65.62,53.35 65.62,52.99 65.87,52.73 65.87,52.59 66.3,52.17 U32.A2
M_A_DQ39: length 13
  BOTTOM w0.089: U7.BH38 66.06,58.43 66.14,58.34 66.14,57.85 66.13,57.84 66.13,57.62
  BOTTOM w0.094: U32.C3 65.72,50.74 65.72,50.93 65.6,51.04 65.41,51.04 65.13,50.76 64.97,50.76 64.83,50.9 64.83,51.03 65,51.2 65,51.33 64.71,51.62 64.71,52.01 64.86,52.16 65.13,52.16 65.22,52.25 65.22,52.45 65.12,52.54 64.89,52.54 64.78,52.64 64.78,54.24 64.89,54.34 65.19,54.34 65.29,54.44 65.29,54.64 65.19,54.74 64.89,54.74 64.78,54.85 64.78,55.16 65.16,55.54 65.16,56.31 65.44,56.59 66.02,56.59 66.16,56.73 66.16,56.91 66.07,56.99 65.74,56.99 65.63,57.1 65.63,57.28 65.82,57.47 65.98,57.47 66.13,57.62
M_A_DQ40: length 25.5
  TOP w0.094: v3(61.13,48.58) 61.14,48.6 61.55,48.19 U25.F2
  IN1 w0.089: 65.71,61.61 65.85,61.74 ; v3(61.13,48.58) 61.13,48.9 61.02,49.01 60.7,49.01 60.61,48.92 60.61,48.04 60.72,47.92 60.72,47.61 60.49,47.39 59.46,47.39 59.37,47.29 59.37,46.99 59.46,46.9 60.58,46.9 61,47.31 61.23,47.31
  IN1 w0.094: 61.23,47.31 61.53,47.61 61.53,47.92 ; 65.85,61.74 66.21,61.74 v1(66.56,61.39) ; 64.28,58.11 64.57,58.41 64.57,58.52 64.73,58.68 64.82,58.68 65.97,59.82 65.97,59.94 65.97,59.94 65.97,60.27 65.97,60.27 65.97,60.47 65.71,60.73 65.71,61.61
  IN1 w0.107: 61.53,47.92 61.53,48.77 61.65,48.89 61.65,49.09 61.53,49.21 61.53,49.73 61.86,50.06 61.86,50.36 61.86,50.37 61.86,50.88 61.74,51.01 61.74,51.17 61.91,51.34 61.91,52.37 62.01,52.48 62.01,53.15 62.83,53.97 62.83,54.48 62.93,54.58 63.27,54.58 63.4,54.71 63.62,54.71 63.73,54.81 63.73,55.04 63.85,55.16 63.85,56.25 63.65,56.44 63.65,56.61 63.85,56.8 63.85,57.65 64.28,58.08 64.28,58.11
  BOTTOM w0.089: U7.BC36 66.62,61.44 v1(66.56,61.39)
M_A_DQ41: length 25.2
  TOP w0.089: U25.H3 62.35,46.58
  TOP w0.094: 62.35,46.58 v3(62.72,46.96)
  IN1 w0.089: v3(62.72,46.96) 63.26,46.96 63.53,46.68 63.53,46.21 63.26,45.94 63.26,45.46 63.49,45.23 63.97,45.23 64.83,46.09 64.83,46.42 64.37,46.88 64.37,47.48 63.78,48.08 63.78,48.33
  IN1 w0.094: v1(66.56,62.1) 66.97,61.7 66.97,59.58 65.98,58.59
  IN1 w0.107: 65.98,58.59 65.98,57.88 64.84,56.74 64.84,54.1 64.71,53.96 64.71,52.62 64.61,52.52 64.21,52.52 64.21,52.52 63.89,52.52 63.66,52.29 63.66,51.98 64.22,51.42 64.22,51.14 64.15,51.07 64.15,51.07 63.86,50.78 63.86,50.78 63,49.92 62.93,49.92 62.72,49.71 62.72,49.39 62.73,49.38 62.73,49.38 63.78,48.33
  BOTTOM w0.089: U7.BA36 v1(66.56,62.1)
M_A_DQ42: length 25.4
  TOP w0.094: U25.F7 65.55,48.25 v3(65.06,48.73)
  IN1 w0.089: v1(68.47,64.24) 68.25,64.45 67.9,64.45 67.81,64.37 67.81,64.2 67.98,64.02 67.98,63.85 67.81,63.67 67.81,59.07
  IN1 w0.107: v3(65.06,48.73) 65.29,48.96 66.2,48.96 66.36,49.12 66.36,50 66.26,50.1 65.44,50.1 65.34,50.21 65.34,50.48 65.47,50.62 67.07,50.62 67.2,50.74 67.2,50.9 67.07,51.02 66.27,51.02 66.15,51.14 66.15,51.32 66.15,51.32 66.15,51.46 66.26,51.57 66.46,51.57 66.56,51.67 66.56,51.87 66.46,51.98 66.26,51.98 66.16,52.08 66.16,52.36 66.15,52.36 66.15,52.36 66.05,52.47 66.05,53.37 66.16,53.48 66.51,53.48 66.61,53.59 66.61,54.6 66.5,54.72 66.24,54.72 66.14,54.82 66.14,55.01 66.25,55.12 66.43,55.12 66.54,55.22 66.54,55.44 66.43,55.54 66.24,55.54 66.14,55.64 66.14,55.83 66.25,55.95 66.43,55.95 66.54,56.05 66.54,56.45 67.2,57.12 67.2,57.5 67.39,57.68 67.63,57.68 67.87,57.92 67.87,58.31 67.81,58.37 67.81,59.07
  BOTTOM w0.089: U7.AU34 v1(68.47,64.24)
M_A_DQ43: length 24.4
  TOP w0.094: U25.H7 65.69,46.57 65.93,46.33 65.93,46.22 v3(65.94,46.2)
  IN1 w0.089: v1(69.46,64.24) 69.32,64.37 69.32,64.59 69.23,64.68 68.98,64.68 68.87,64.57 68.87,59.78 68.47,59.37 68.47,57.5 ; 67.44,48.11 67.21,47.88 67.21,47.65 66.92,47.36 66.54,47.36 66.35,47.17 66.35,46.61 v3(65.94,46.2)
  IN1 w0.107: 67.44,48.11 68.85,48.11 69.13,48.39 69.13,49.76 67.17,51.72 67.17,52.75 67.76,53.33 67.76,53.99 67.8,54.04 67.8,56.81 67.81,56.82 67.81,56.84 68.47,57.5
  BOTTOM w0.089: U7.AU32 69,64.57 v1(69.46,64.24)
M_A_DQ44: length 23.2
  TOP w0.094: U25.G2 61.56,47.37 v3(61.96,47.77)
  IN1 w0.089: 61.58,46.79 61.01,46.22 61.01,45.92 61.1,45.83 62.82,45.83 62.98,45.99 62.98,46.47 62.9,46.55 62.52,46.55 62.34,46.73 62.34,47.41 ; 61.58,47.27 61.81,47.5 61.81,47.61 v3(61.96,47.77)
  IN1 w0.094: 61.58,47.27 61.58,46.79 ; 65.12,58.4 65.36,58.64 65.76,58.64 66.56,59.44 v1(66.56,59.97)
  IN1 w0.107: 65.12,58.4 65.12,58.18 64.84,57.9 64.84,57.78 64.5,57.44 64.5,54.59 64.56,54.53 64.56,54.21 64.43,54.08 64.43,52.92 64.31,52.8 63.77,52.8 63.23,52.26 63.23,52.02 63.9,51.35 63.9,51.21 62.89,50.21 62.83,50.21 62.45,49.82 62.45,49.59 62.45,49.27 62.23,49.05 62.23,48.83 62.32,48.74 62.32,48.74 62.36,48.69 62.36,48.45 62.59,48.22 62.59,48.22 62.65,48.17 62.65,47.72 62.34,47.41
  BOTTOM w0.089: U7.BF36 v1(66.56,59.97)
M_A_DQ45: length 23.6
  TOP w0.094: U25.E3 v3(61.94,49.37)
  IN1 w0.094: v1(66.56,60.68) 66.2,61.04 66.04,61.04 65.94,60.94 65.94,60.81 66.15,60.59 66.15,59.47 65.59,58.91 65.32,58.91 64.84,58.42
  IN1 w0.107: v3(61.94,49.37) 61.86,49.45 61.86,49.66 61.94,49.74 62.48,50.28 62.48,50.42 62.14,50.76 62.14,50.91 62.29,51.06 62.44,51.06 62.85,50.65 62.95,50.65 63.15,50.85 63.15,50.95 62.67,51.43 62.29,51.43 62.19,51.54 62.19,51.74 62.29,51.84 62.75,51.84 62.86,51.95 62.86,52.15 62.76,52.25 62.39,52.25 62.29,52.35 62.29,52.88 62.4,52.99 62.55,52.99 62.98,52.56 63.12,52.56 63.26,52.7 63.26,52.84 62.76,53.35 62.76,53.49 62.96,53.69 63.1,53.69 63.69,53.1 64.04,53.1 64.14,53.2 64.14,53.55 64.04,53.66 63.71,53.66 63.31,54.05 63.31,54.23 63.48,54.39 63.62,54.39 63.91,54.11 64.06,54.11 64.24,54.29 64.24,54.46 64.01,54.69 64.01,54.85 64.13,54.97 64.13,57.53 64.56,57.96 64.56,58.01 64.84,58.29 64.84,58.42
  BOTTOM w0.089: U7.BD36 v1(66.56,60.68)
M_A_DQ46: length 24.5
  TOP w0.094: U25.F8 66.33,48.17 v3(65.95,48.55)
  IN1 w0.089: v1(68.47,63.53) 68.32,63.68 68.14,63.68 68.01,63.55 68.01,58.83 68.14,58.71 68.14,57.65 ; v3(65.95,48.55) 66.35,48.15 66.91,48.15 67.14,48.38
  IN1 w0.107: 67.14,48.38 67.14,49.63 67.29,49.77 67.73,49.77 68.11,49.39 68.11,48.58 68.24,48.45 68.75,48.45 68.85,48.55 68.85,49.66 66.9,51.6 66.9,51.61 66.88,51.63 66.88,53.21 66.99,53.32 67.31,53.32 67.42,53.42 67.42,53.61 67.31,53.72 66.99,53.72 66.89,53.82 66.89,56.4 68.14,57.65
  BOTTOM w0.089: U7.AV34 v1(68.47,63.53)
M_A_DQ47: length 25.4
  TOP w0.094: U25.H8 66.35,46.57 v3(66.74,46.95)
  IN1 w0.089: 68.75,59.15 69.05,59.46 69.05,63.44 69.14,63.53 v1(69.46,63.53)
  IN1 w0.107: v3(66.74,46.95) 67.04,46.65 67.73,46.65 68.23,47.15 68.57,47.15 68.96,46.77 69.34,46.77 69.5,46.93 69.5,48.55 69.66,48.71 70.99,48.71 71.14,48.86 71.14,49.04 70.99,49.19 69.69,49.19 69.41,49.47 69.41,49.88 68.03,51.25 68.03,53.87 68.07,53.91 68.07,56.7 68.75,57.37 68.75,59.15
  BOTTOM w0.089: v1(69.46,63.53) 69,63.85 U7.AV32
M_A_DQ48: length 19.4
  IN2 w0.089: 63.56,50.02 63.56,49.42 63.16,49.02 63.16,48.76 63.66,48.27 63.66,48.05 63.47,47.86 v3(63.44,47.86) ; 66.7,57.34 66.88,57.52 66.88,58.49 66.99,58.6 67.38,58.6 67.49,58.7 67.49,59.06 67.65,59.22 67.96,59.22 68.2,59.46 68.2,59.7 v1(68.47,59.97)
  IN2 w0.107: 66.7,57.34 66.18,56.82 66.18,56.4 64.12,54.34 64.12,53.65 63.67,53.19 63.67,53 63.74,52.93 64,52.93 64.07,52.86 64.07,52.62 63.96,52.51 63.77,52.51 63.66,52.4 63.66,51.86 63.77,51.75 63.93,51.75 64.05,51.63 64.05,51.4 63.9,51.25 63.41,51.25 63.31,51.15 63.31,50.95 63.41,50.85 63.54,50.85 63.67,50.72 63.67,50.12 63.56,50.02
  BOTTOM w0.089: U7.BF34 v1(68.47,59.97)
  BOTTOM w0.094: U32.H7 62.86,46.57 63.1,46.8 63.1,47.08 63.46,47.45 63.46,47.58 63.44,47.61 v3(63.44,47.86)
M_A_DQ49: length 19.6
  IN2 w0.089: v1(68.47,61.39) 68.12,61.39 67.91,61.18 67.91,60.87 68.05,60.73 68.05,60.61 67.92,60.48 67.8,60.48 67.74,60.54 67.61,60.54 67.52,60.45 ; 62.52,50.16 62.52,48.99 62.37,48.83 62.37,47.36 v3(61.96,46.95)
  IN2 w0.107: 67.52,60.45 67.52,60.44 67.52,60.44 67.52,59.88 66.26,58.61 66.26,57.8 63.28,54.83 63.28,54.36 63.54,54.11 63.54,53.97 63.41,53.83 63.24,53.83 63.17,53.9 62.93,53.9 62.76,53.73 62.76,53.72 62.45,53.41 62.45,53.27 62.59,53.13 62.59,52.99 62.45,52.85 62.45,50.24 62.52,50.16
  BOTTOM w0.089: U7.BC34 68.41,61.44 v1(68.47,61.39)
  BOTTOM w0.094: U32.H8 61.57,46.57 v3(61.96,46.95)
M_A_DQ50: length 18.8
  IN2 w0.089: 68.82,57.26 68.82,58.49 70.05,59.72 70.05,62.22 v1(69.46,62.81)
  IN2 w0.107: v3(65.05,49.51) 65.05,49.64 66.81,51.4 67.78,51.4 67.8,51.42 67.91,51.42 68.03,51.55 68.03,52.88 67.92,53 67.38,53 67.28,53.1 67.28,53.31 67.38,53.41 67.8,53.41 68.08,53.69 68.08,56.53 68.82,57.26
  BOTTOM w0.089: U32.E3 65.54,48.97 ; U7.BA32 69.23,62.66 v1(69.46,62.81)
  BOTTOM w0.094: 65.54,48.97 65.05,49.46 v3(65.05,49.51)
M_A_DQ51: length 20.3
  IN2 w0.089: 70.22,58.39 70.22,58.91 ; 71.04,60.8 v1(70.45,61.39)
  IN2 w0.094: 70.22,58.91 71.04,59.73 71.04,60.8
  IN2 w0.107: 70.22,58.39 70.22,56.98 70.02,56.78 70.02,56.17 70.29,55.9 70.29,55.27 70.13,55.11 69.68,55.11 69.42,54.86 69.42,54.68 69.78,54.32 69.78,54.12 69,53.34 69,53.32 69,53.32 69,51.33 68.87,51.2 68.87,51.05 69.01,50.91 69.01,50.55 68.68,50.22 68.68,50 69.11,49.57 69.11,49.43 68.97,49.28 68.82,49.28 68.78,49.32 68.64,49.32 68.25,48.94 68.11,48.94 67.97,49.08 67.97,49.22 68.35,49.61 68.35,49.76 68.22,49.89 68.08,49.89 67.91,49.72 67.36,49.72 67.19,49.55 67.19,48.97 v3(66.75,48.53)
  BOTTOM w0.089: v1(70.45,61.39) 70.17,61.19 U7.BD30
  BOTTOM w0.094: U32.F2 66.39,48.17 v3(66.75,48.53)
M_A_DQ52: length 19.4
  IN2 w0.089: 62.73,50.06 62.72,50.05 62.72,49.4 62.75,49.38 v3(62.75,48.61) ; 66.61,58.3 66.61,58.53 67.96,59.88 67.96,60.17 v1(68.47,60.68)
  IN2 w0.107: 62.73,50.06 62.73,50.1 62.83,50.2 63.28,50.2 63.36,50.28 63.36,50.51 63.26,50.61 62.83,50.61 62.72,50.72 62.72,51.89 62.83,52 63.26,52 63.36,52.1 63.36,52.31 63.26,52.41 62.83,52.41 62.73,52.51 62.73,52.64 63.07,52.99 63.07,53.13 62.93,53.27 62.93,53.41 63.08,53.55 63.22,53.55 63.36,53.42 63.5,53.42 63.84,53.76 63.84,54.59 63.84,54.92 63.95,55.02 64.09,55.02 64.17,54.94 64.32,54.94 64.46,55.08 64.46,55.23 64.38,55.31 64.38,55.45 64.52,55.6 64.66,55.6 64.75,55.51 64.89,55.51 65.03,55.66 65.03,55.8 64.95,55.88 64.95,56.03 65.27,56.35 65.42,56.35 65.47,56.29 65.62,56.29 65.76,56.43 65.76,56.58 65.7,56.64 65.7,56.78 66.61,57.68 66.61,58.3
  BOTTOM w0.089: U7.BD34 v1(68.47,60.68)
  BOTTOM w0.094: U32.F7 62.35,48.21 v3(62.75,48.61)
M_A_DQ53: length 17.5
  IN2 w0.089: v3(61.94,48.58) 61.94,48.83 62.32,49.21 62.32,49.97 ; v1(68.47,62.1) 68.47,62.02 67.25,60.8 67.25,60.09 65.98,58.82 65.98,57.92
  IN2 w0.107: 65.98,57.92 62.57,54.51 62.57,53.94 62.17,53.53 62.17,50.12 62.32,49.97
  BOTTOM w0.089: U32.F8 61.55,48.19 ; U7.BA34 v1(68.47,62.1)
  BOTTOM w0.094: 61.55,48.19 v3(61.94,48.58)
M_A_DQ54: length 20.9
  IN2 w0.089: v1(70.45,59.97) 70.45,59.82 69.1,58.47
  IN2 w0.107: v3(65.07,46.83) 64.65,46.83 64.55,46.72 64.55,46.44 64.66,46.32 65.51,46.32 65.67,46.48 65.67,46.7 65.56,46.81 65.56,46.81 65.56,47.18 65.46,47.28 65.34,47.28 65.24,47.39 65.24,47.59 65.34,47.69 65.42,47.69 65.54,47.81 65.54,48 65.29,48.25 65.29,48.4 65.47,48.58 65.47,49.65 65.75,49.92 65.89,49.92 66.05,49.76 66.2,49.76 66.31,49.88 66.31,50.03 66.15,50.19 66.15,50.33 66.94,51.12 67.42,51.12 67.55,51 67.77,51 67.92,51.15 68.11,51.15 68.22,51.25 68.22,51.34 68.37,51.5 68.37,56.42 69.09,57.14 69.09,58.29 69.1,58.3 69.1,58.47
  BOTTOM w0.089: v1(70.45,59.97) 70.17,60.19 U7.BF30
  BOTTOM w0.094: v3(65.07,46.83) 65.07,46.77 65.27,46.57 65.54,46.57 U32.H3
M_A_DQ55: length 20.7
  IN2 w0.094: v1(70.45,60.68) 70.85,60.28 70.85,60.14 70.85,60.14 70.85,59.8 69.94,58.89
  IN2 w0.107: 69.94,58.89 69.94,57.09 69.74,56.89 69.37,56.89 69.09,56.61 69.09,56.15 69.4,55.84 69.4,55.23 69.33,55.16 68.85,55.16 68.75,55.06 68.75,54.55 68.85,54.45 69.25,54.45 69.35,54.35 69.35,54.15 69.25,54.05 68.85,54.05 68.72,53.92 68.72,51.45 68.49,51.22 68.49,51.04 68.7,50.83 68.7,50.69 68.53,50.52 68.23,50.52 68.09,50.65 67.48,50.65 67.37,50.76 67.08,50.76 66.98,50.66 66.98,50.5 67.15,50.33 67.21,50.33 67.31,50.23 67.31,50.07 67.01,49.76 66.6,49.76 66.59,49.75 66.59,49.75 66.36,49.53 66.36,49.21 66.36,49.21 66.36,49.18 66.54,49.01 66.54,48.86 66.37,48.69 66.37,48.37 66.54,48.21 66.54,48.06 66.4,47.93 66.4,47.73 66.3,47.63 66.06,47.63 v3(65.92,47.77)
  BOTTOM w0.089: U7.BD28 v1(70.45,60.68)
  BOTTOM w0.094: U32.G2 66.32,47.37 v3(65.92,47.77)
M_A_DQ56: length 13.2
  TOP w0.094: U25.A3 62.62,52.45 62.86,52.45 63.03,52.62 63.03,52.85 63.2,53.02 63.43,53.02 63.6,53.19 63.6,53.42 63.77,53.6 64.01,53.6 64.18,53.77 64.18,54 64.35,54.17 64.58,54.17 64.75,54.34 64.75,54.57 64.92,54.75 65.16,54.75 65.33,54.92 65.33,55.15 65.44,55.26 66.2,55.26 66.31,55.16 66.31,55.03 66.41,54.93 66.61,54.93 66.71,55.03 66.71,55.16 66.81,55.26 66.94,55.26 v1(67.32,54.88)
  BOTTOM w0.089: 68.29,57.7 68.29,58.5 U7.BJ33
  BOTTOM w0.094: 68.29,57.7 67.98,57.39 67.98,57.19 68.06,57.11 68.23,57.11 68.33,57.01 68.33,56.8 68.24,56.7 68.09,56.7 67.99,56.6 67.99,56.4 68.09,56.29 68.25,56.29 68.33,56.21 68.33,55.98 68.19,55.84 68.19,55.72 68.34,55.56 68.34,55.39 68.21,55.26 68.08,55.26 67.94,55.4 67.79,55.4 67.32,54.93 v1(67.32,54.88)
M_A_DQ57: length 14.3
  TOP w0.094: U25.A7 65.54,52.17 65.54,52.68 65.96,53.09 67.25,53.09 67.32,53.16 68.17,53.16 68.36,53.35 68.36,53.37 68.92,53.93 68.92,53.93 69,54.01 69,54.15 68.9,54.25 68.9,54.39 69.03,54.51 69.21,54.51 69.53,54.2 69.79,54.2 69.95,54.35 69.95,54.5 69.72,54.73 69.72,54.98 70.28,55.54 70.28,56.11 70.12,56.27 70.12,56.77 70,56.89 69.68,56.89 69.55,56.76 69.55,56.5 v1(69.57,56.48)
  BOTTOM w0.089: 70.21,57.41 70.21,58.27 70.12,58.35 70.12,58.83 70.37,59.08 70.37,59.38 U7.BG29
  BOTTOM w0.094: 70.21,57.41 70.05,57.25 70.05,57.13 70.29,56.89 70.29,56.76 70.16,56.64 70.04,56.64 69.8,56.88 69.64,56.88 69.55,56.79 69.55,56.5 v1(69.57,56.48)
M_A_DQ58: length 12.1
  TOP w0.094: U25.A2 65.63,56.25 65.89,56.25 65.99,56.15 65.99,55.92 66.09,55.82 66.29,55.82 66.4,55.92 66.4,56.17 66.5,56.28 v1(67.39,56.28)
  BOTTOM w0.089: 67.91,57.94 67.91,58.99 U7.BH34
  BOTTOM w0.094: 67.91,57.94 67.58,57.61 67.58,57.27 67.48,57.17 67.15,57.17 67.04,57.07 67.04,56.87 67.15,56.77 67.48,56.77 67.58,56.67 67.58,56.47 v1(67.39,56.28)
M_A_DQ59: length 14.6
  TOP w0.094: U25.C3 62.77,50.99 63.12,50.99 63.51,51.38 63.51,51.73 63.44,51.81 63.44,52.39 63.52,52.47 63.52,52.7 63.89,53.07 64.14,53.07 64.3,53.23 64.3,53.49 64.46,53.65 64.72,53.65 64.88,53.81 64.88,54.06 65.47,54.65 66.82,54.65 67.07,54.4 67.12,54.4 67.28,54.24 v1(67.35,54.24)
  BOTTOM w0.089: U7.BG32 68.97,59.49 68.67,59.19 68.67,58.95 68.77,58.85 68.77,58.52 68.5,58.26 68.5,57.6
  BOTTOM w0.094: 68.5,57.6 68.54,57.56 68.54,55.17 68.4,55.03 67.98,55.03 67.81,54.86 67.81,54.7 v1(67.35,54.24)
M_A_DQ60: length 15.3
  TOP w0.089: 68.35,50.87 68.26,50.95 68.26,51.13 68.17,51.22 67.99,51.22 67.9,51.13 67.9,50.97 67.81,50.88 66.66,50.88 U25.C8
  TOP w0.094: v1(70.04,53.41) 70.04,52.77 70.18,52.63 70.42,52.63 70.55,52.5 70.55,52.22 70.4,52.07 68.97,52.07 68.96,52.06 68.95,52.06 68.85,51.96 68.85,51.95 68.8,51.89 68.8,51.04 68.62,50.87 68.35,50.87
  BOTTOM w0.089: 70.76,57.21 70.76,58.8 70.62,58.95 70.62,59.19 70.92,59.5 U7.BG28
  BOTTOM w0.094: v1(70.04,53.41) 70.28,53.41 70.36,53.48 70.61,53.48 70.74,53.61 70.75,53.61 70.85,53.71 70.85,53.95 70.96,54.05 71.06,54.05 71.16,54.15 71.16,54.35 71.06,54.46 70.97,54.46 70.87,54.56 70.87,54.87 71.18,55.18 71.18,56.78 70.76,57.21
M_A_DQ61: length 14.9
  TOP w0.094: v1(70.73,55.73) 70.73,55.73 71.03,55.73 71.13,55.63 71.13,55.02 70.94,54.82 70.37,54.82 70.27,54.73 70.27,54.44 70.35,54.37 70.78,54.37 70.91,54.24 70.91,54.03 70.8,53.92 69.31,53.92 69.2,53.81 69.2,53.81 68.94,53.55 68.94,53.38 68.96,53.36 68.96,53.21 68.82,53.07 68.67,53.07 68.65,53.09 68.51,53.09 68.34,52.92 67.76,52.92 67.72,52.97 67.41,52.97 67.17,52.73 67.17,52.69 66.69,52.22 66.69,52.02 66.49,51.82 66.29,51.82 65.89,51.42 65.89,51.22 65.82,51.15 65.82,50.78 65.89,50.71 65.89,50.42 65.82,50.35 65.82,50.08 65.79,50.05 65.79,49.96 65.6,49.77 U25.D7
  BOTTOM w0.089: 70.49,57.14 70.49,58.35 70.43,58.41 U7.BJ29
  BOTTOM w0.094: 70.49,57.14 70.96,56.68 70.96,55.96 v1(70.73,55.73)
M_A_DQ62: length 15.7
  TOP w0.089: 68.43,51.41 67.8,51.41 67.71,51.32 67.71,51.14 67.62,51.06 67.02,51.06 66.85,51.22 66.73,51.22 66.45,50.94 66.2,50.94 66.11,51.03 66.11,51.13 U25.B8
  TOP w0.094: 68.43,51.41 68.52,51.5 68.52,51.72 68.43,51.81 68.12,51.81 68.03,51.91 68.03,52.17 67.96,52.24 67.96,52.54 68.05,52.63 68.21,52.63 68.53,52.31 68.7,52.31 68.8,52.41 68.8,52.67 68.9,52.77 69.11,52.77 69.21,52.67 69.21,52.45 69.31,52.35 69.49,52.35 v1(69.66,52.52)
  BOTTOM w0.089: 70.99,57.33 70.99,59 U7.BH28
  BOTTOM w0.094: v1(69.66,52.52) 69.86,52.31 70.24,52.31 70.45,52.52 70.45,53.05 70.52,53.12 70.52,53.13 70.6,53.2 70.74,53.2 71.13,53.6 71.13,53.61 71.34,53.81 71.42,53.81 71.52,53.91 71.52,54.06 71.44,54.14 71.44,56.89 70.99,57.33
M_A_DQ63: length 13
  TOP w0.094: U25.C2 61.91,50.93 61.91,52.2 62.21,52.49 62.27,52.49 65.32,55.54 v1(67.35,55.54)
  BOTTOM w0.089: U7.BG33 68.31,59.26 68.31,58.96 68.1,58.75 68.1,57.85
  BOTTOM w0.094: 68.1,57.85 67.79,57.53 67.79,55.98 v1(67.35,55.54)
M_A_DQSN0: length 43.9
  IN2 w0.089: 41.94,49.7 41.96,49.7 42,49.75 42.39,49.75 42.48,49.66 42.48,49.05 42.67,48.86 43.53,48.86 43.71,48.68 44.07,48.68 44.78,47.98 44.78,47.75 44.97,47.56 45.34,47.56 v3(45.56,47.34)
  IN2 w0.14: 41.94,49.7 41.63,49.7 41.17,50.16 41.17,51.01 40.82,51.35 40.82,56.04 43.4,58.62 43.8,58.62 44.12,58.94 44.12,59.34 44.47,59.69 44.87,59.69 45.11,59.93 45.11,60.32 45.49,60.71 46.79,60.71 51.48,65.4 53.02,65.4 53.31,65.1 53.31,64.77 v1(53.51,64.57)
  BOTTOM w0.089: U31.G3 47.77,47.6 47.69,47.68 47.65,47.68 47.53,47.68 47.38,47.83 47.38,47.86 47.16,48.08 47.13,48.08 47.05,48.16 46.72,48.16 46.2,47.64 46.12,47.64 46.06,47.57 45.64,47.57 45.55,47.49 45.55,47.36 45.56,47.35 v3(45.56,47.34) ; U7.AM51 59.39,67.1 59.09,66.8 58.85,66.8 58.73,66.92 58.27,66.92 58.27,66.93
  BOTTOM w0.102: 58.27,66.93 58.17,67.02 57.84,67.02 57.42,66.6 56.83,66.6 56.83,66.6
  BOTTOM w0.127: v1(53.51,64.57) 53.32,64.76 53.32,65.06 52.9,65.48 52.58,65.48 52.47,65.58 52.47,65.87 52.57,65.97 53.65,65.97 53.84,65.78 53.84,65.31 54.07,65.08 54.45,65.08 54.67,65.3 54.67,65.75 54.77,65.85 56.07,65.85 56.83,66.6
M_A_DQSN1: length 36.4
  TOP w0.089: v3(45.89,49.54) 45.35,49.54 45.18,49.37 45.18,49.24 45.66,48.76 45.66,48.49 45.31,48.13 45.31,47.93 45.07,47.69 44.64,47.69 44.57,47.61 U24.G3
  IN1 w0.089: 51.16,63.09 51.58,62.68 55.23,62.68 55.32,62.77 55.32,62.98 55.53,63.2 55.85,63.2 56.05,62.99 56.05,62.77 56.14,62.68 56.32,62.68 56.41,62.77 56.41,62.99 56.6,63.18 56.93,63.18 57.12,62.99 57.12,62.77 57.21,62.68 57.42,62.68 57.51,62.77 57.51,62.99 57.7,63.18 58.03,63.18 58.22,62.99 58.22,62.77 58.31,62.68 58.99,62.68 59.58,63.27 60.44,63.27 60.58,63.4 v1(60.58,63.68) ; v3(45.89,49.54) 45.76,49.68 45.32,49.68 44.93,50.07 44.93,50.31 44.64,50.6 44.64,51.02 44.15,51.51 44.04,51.51 44.02,51.54
  IN1 w0.14: 44.02,51.54 43.92,51.64 43.92,51.81 43.29,52.44 43.29,57.39 49.16,63.26 49.62,63.26 50.02,62.86 50.27,62.86 50.61,63.21 51.05,63.21 51.16,63.09
  BOTTOM w0.089: U7.AV48 v1(60.58,63.68)
M_A_DQSN2: length 41.7
  IN2 w0.089: v3(47.16,53.08) 47.37,52.87 47.54,52.87 47.63,52.96 47.63,53.77 47.58,53.82 47.58,53.83 ; 58.77,63.87 58.79,63.89 58.85,63.89 59.29,64.33 59.29,64.91 59.64,65.26 63.66,65.26 63.87,65.04 63.87,64.93 v1(64.14,64.67)
  IN2 w0.14: 58.77,63.87 57.66,62.76 57.66,62.38 56.99,61.7 56.99,61.13 57.26,60.85 57.26,60.41 56.99,60.13 56.99,59.55 57.26,59.27 57.26,57.54 57.01,57.28 56.58,57.28 56.2,56.91 56.2,56.49 56.59,56.1 57.39,56.1 57.53,55.96 57.53,55.6 57.34,55.41 54.97,55.41 54.88,55.32 53.88,55.32 53.59,55.02 53.59,52.9 53.45,52.76 53.17,52.76 53.03,52.9 53.03,55.02 52.73,55.32 51.43,55.32 51.14,55.02 51.14,53.96 50.99,53.82 50.74,53.82 50.58,53.98 50.58,55.02 50.28,55.32 48.64,55.32 47.58,54.26 47.58,53.83
  BOTTOM w0.089: U7.AT41 v1(64.14,64.67)
  BOTTOM w0.102: v3(47.16,53.08) 47.16,52.97 47.05,52.86 47.02,52.86 46.52,52.86 46.25,52.59 46.25,52.25 46.01,52.01 45.87,52.01 44.92,51.06 44.71,51.06 44.57,51.2 U31.B7
M_A_DQSN3: length 23.6
  TOP w0.127: U24.B7 47.81,51.37 v3(48.21,50.97)
  IN1 w0.089: v3(48.21,50.97) 48.21,50.73 48.13,50.66 47.98,50.66 47.83,50.8 47.83,51.1 47.76,51.17 47.76,53.33 47.76,53.46 47.51,53.71 47.51,53.78 47.51,53.79
  IN1 w0.14: 47.51,53.79 47.28,54.01 47.28,56.23 47.49,56.44 48.43,56.44 48.75,56.76 48.75,57.66 48.89,57.8 49.68,57.8 49.98,58.1 49.98,59 50.21,59.23 51.62,59.23 51.71,59.32 52.76,59.32 v1(53.46,60.01)
  BOTTOM w0.102: U7.BA51 59.03,62.73 58.75,63.01 57.7,63.01 55.95,61.26 55.87,61.26 55.59,60.97 55.59,60.95 55.46,60.82 55.42,60.82
  BOTTOM w0.127: 55.42,60.82 53.58,60.82 53.25,60.49 53.25,60.22 v1(53.46,60.01)
M_A_DQSN4: length 11.5
  BOTTOM w0.089: 63.12,52.01 63.08,51.97 62.87,51.97 62.78,51.88 62.78,51.88 62.58,51.68 62.14,51.68 62.03,51.58 62.03,51.21 62.12,51.12 62.27,51.12 62.35,51.2 U32.B7
  BOTTOM w0.102: U7.BG39 65.38,59.24 65.38,58.95 65.25,58.83 65.25,58.6 65.06,58.41 65.06,57.89 65.16,57.79 65.16,56.94 64.82,56.6 64.33,56.6 64.23,56.49 64.23,56.35 64.56,56.01 64.56,55.64 64.15,55.22 64.15,54.82 64.13,54.81 64.13,52.77 63.92,52.56 63.67,52.56 63.58,52.46 63.58,52.24 63.35,52.01 63.12,52.01
M_A_DQSN5: length 23
  TOP w0.089: v3(63.99,48.8) 63.99,48.87 63.84,49.01 63.69,49.01 63.49,48.81 63.49,48.57 62.98,48.06 62.96,48.06 62.6,47.69 62.43,47.69 62.35,47.6 U25.G3
  IN1 w0.076: v3(63.99,48.8) 63.99,48.83 63.84,48.99 63.65,48.99 63.48,49.16 63.48,49.44 63.48,49.83 63.66,50.02 63.66,50.05
  IN1 w0.089: 66.31,57.2 66.39,57.28 66.39,57.28 66.67,57.55 66.67,58.54 67.43,59.3 67.43,64.83 68.03,65.44 68.24,65.44 v1(68.47,65.66)
  IN1 w0.14: 63.66,50.05 64.37,50.75 64.67,50.75 65.35,51.43 65.35,51.43 65.51,51.59 65.51,51.92 65.51,52.1 65.4,52.2 65.4,53.64 65.49,53.73 65.49,56.38 66.31,57.2
  BOTTOM w0.089: U7.AT34 v1(68.47,65.66)
M_A_DQSN6: length 19
  IN2 w0.089: v1(69.46,62.1) 69.25,61.89 69.09,61.89 68.87,61.68 68.87,59.64 68.37,59.13 68.34,59.13 ; v3(64.16,48.24) 64.34,48.42 64.34,48.62 64.39,48.67 64.39,49.58 64.18,49.8 64.18,50.15 64.18,50.48 64.15,50.5 64.15,50.51
  IN2 w0.14: 64.15,50.51 64.15,50.97 64.43,51.25 64.43,52.02 64.49,52.08 64.49,53.49 64.65,53.64 64.65,54.07 66.56,55.98 66.56,56.43 66.77,56.64 67.9,57.77 67.9,58.69 68.34,59.13
  BOTTOM w0.089: U32.G3 65.55,47.56 65.42,47.69 64.48,47.69 64.29,47.88 64.29,48.11 v3(64.16,48.24) ; U7.BC32 v1(69.46,62.1)
M_A_DQSN7: length 14.3
  TOP w0.076: 67.88,53.43 67.6,53.43 67.57,53.45 66.73,53.45 66.58,53.3 65.54,53.3 65.34,53.1 65.34,52.86 65.05,52.57 64.83,52.57 64.68,52.41 64.68,51.63 64.43,51.39 64.43,50.92 64.57,50.78 64.76,50.78 64.99,51.02 65.26,51.02 65.55,51.31 U25.B7
  TOP w0.127: 67.88,53.43 68.51,54.06 68.51,54.56 68.85,54.9 69.14,54.9 69.39,55.15 69.39,55.31 69.77,55.69 v1(69.81,55.69)
  BOTTOM w0.102: U7.BG31 69.25,58.93 69.16,58.84 69.16,58.36 69.15,58.36 69.15,58.35 69.07,58.27 69.07,57.66 69.07,57.49 69.03,57.45 69.03,57.43 69.02,57.42
  BOTTOM w0.127: 69.02,57.42 69.02,56.44 69.77,55.69 v1(69.81,55.69)
M_A_DQSP0: length 43.8
  IN2 w0.089: v3(45.71,48.01) 45.71,48.45 45.62,48.54 45.45,48.54 45.29,48.38 45.29,47.8 45.23,47.74 45.04,47.74 44.96,47.82 44.96,48.05 44.15,48.86 43.78,48.86 43.6,49.04 42.74,49.04 42.65,49.13 42.65,49.73 42.46,49.92 41.99,49.92 41.94,49.97
  IN2 w0.14: v1(52.67,64.56) 52.82,64.56 53.04,64.78 53.04,64.99 52.9,65.13 51.59,65.13 46.9,60.44 45.6,60.44 45.37,60.21 45.37,59.82 44.98,59.42 44.58,59.42 44.39,59.23 44.39,58.83 43.91,58.35 43.51,58.35 41.09,55.93 41.09,51.47 41.28,51.27 41.44,51.12 41.44,50.27 41.75,49.97 41.94,49.97
  BOTTOM w0.089: v3(45.71,48.01) 45.67,47.97 45.67,47.84 45.76,47.75 45.98,47.75 46.05,47.81 46.13,47.81 46.65,48.34 47.12,48.34 47.2,48.26 47.23,48.26 47.56,47.94 47.56,47.9 47.6,47.86 47.69,47.86 47.77,47.93 U31.F3
  BOTTOM w0.102: 56.73,66.8 57.33,66.8 57.75,67.22 58.26,67.22 58.36,67.12 58.95,67.12 U7.AM52
  BOTTOM w0.127: v1(52.67,64.56) 52.8,64.42 52.99,64.42 53.09,64.52 53.09,64.98 52.81,65.26 52.49,65.26 52.25,65.49 52.25,65.96 52.48,66.19 53.74,66.19 54.06,65.87 54.06,65.4 54.16,65.3 54.36,65.3 54.45,65.39 54.45,65.84 54.68,66.06 55.98,66.06 56.73,66.8
M_A_DQSP1: length 36.4
  TOP w0.089: U24.F3 44.57,47.93 44.63,47.87 45,47.87 45.13,48 45.13,48.21 45.48,48.56 45.48,48.68 45,49.17 45,49.44 45.28,49.72 45.53,49.72 45.84,50.02 v3(45.84,50.13)
  IN1 w0.089: v1(61.29,63.68) 61.15,63.68 60.78,63.31 60.74,63.31 60.52,63.09 59.65,63.09 59.07,62.5 58.24,62.5 58.04,62.69 58.04,62.92 57.95,63.01 57.78,63.01 57.69,62.92 57.69,62.69 57.49,62.5 57.13,62.5 56.94,62.69 56.94,62.92 56.85,63.01 56.67,63.01 56.59,62.92 56.59,62.69 56.39,62.5 56.07,62.5 55.87,62.69 55.87,62.92 55.77,63.02 55.6,63.02 55.49,62.91 55.49,62.69 55.3,62.5 51.5,62.5 51.12,62.88 50.99,62.88 50.98,62.9 ; v3(45.84,50.13) 45.84,50.02 45.67,49.85 45.39,49.85 45.1,50.14 45.1,50.39 44.82,50.67 44.82,51.1 44.22,51.7 44.22,51.72
  IN1 w0.14: 44.22,51.72 44.19,51.75 44.19,51.92 43.56,52.55 43.56,57.28 49.27,62.99 49.51,62.99 49.91,62.6 50.38,62.6 50.72,62.94 50.94,62.94 50.98,62.9
  BOTTOM w0.089: v1(61.29,63.68) U7.AV47
M_A_DQSP2: length 41.6
  IN2 w0.089: 47.84,53.83 47.81,53.79 47.81,52.88 47.62,52.69 47.22,52.69 47.14,52.61 v3(47.14,52.39) ; v1(63.43,64.67) 63.54,64.67 63.7,64.82 63.7,64.97 63.58,65.08 59.72,65.08 59.47,64.84 59.47,64.26 58.98,63.76 58.98,63.7 58.96,63.68
  IN2 w0.14: 47.84,53.83 47.84,54.15 48.75,55.05 50.17,55.05 50.31,54.91 50.31,53.87 50.63,53.55 51.1,53.55 51.4,53.85 51.4,54.91 51.54,55.05 52.62,55.05 52.76,54.91 52.76,52.79 53.06,52.49 53.56,52.49 53.85,52.79 53.85,54.91 53.99,55.05 54.99,55.05 55.08,55.15 57.45,55.15 57.8,55.49 57.8,56.07 57.5,56.36 56.7,56.36 56.46,56.6 56.46,56.8 56.69,57.02 57.12,57.02 57.53,57.43 57.53,57.65 57.53,59.38 57.25,59.66 57.25,60.02 57.53,60.3 57.53,60.96 57.25,61.24 57.25,61.59 57.93,62.27 57.93,62.65 58.96,63.68
  BOTTOM w0.089: v1(63.43,64.67) U7.AT42
  BOTTOM w0.102: v3(47.14,52.39) 47.14,52.54 47.02,52.67 46.6,52.67 46.44,52.51 46.44,52.18 46.09,51.82 45.95,51.82 45,50.86 44.81,50.86 44.67,50.86 44.57,50.76 U31.C7
M_A_DQSP3: length 23.6
  TOP w0.127: v3(48.17,50.17) 48.16,50.17 U24.C7
  IN1 w0.089: 47.33,53.59 47.59,53.33 47.59,51.1 47.65,51.03 47.65,50.73 47.9,50.48 48.07,50.48 48.17,50.38 v3(48.17,50.17)
  IN1 w0.14: v1(52.74,60.01) 52.74,59.72 52.61,59.58 51.6,59.58 51.51,59.5 50.1,59.5 49.71,59.11 49.71,58.21 49.57,58.07 48.78,58.07 48.48,57.77 48.48,56.87 48.32,56.71 47.38,56.71 47.02,56.34 47.02,53.9 47.33,53.59
  BOTTOM w0.102: 55.37,61.04 55.79,61.46 55.86,61.46 57.61,63.21 58.84,63.21 58.84,63.21 U7.AY52
  BOTTOM w0.127: v1(52.74,60.01) 52.86,60.01 53.03,60.18 53.03,60.58 53.49,61.04 55.37,61.04
M_A_DQSP4: length 11.5
  BOTTOM w0.089: U32.C7 62.4,50.62 62.4,50.86 62.32,50.94 62.05,50.94 61.86,51.13 61.86,51.65 62.06,51.86 62.5,51.86 62.8,52.15 63,52.15 63.05,52.19 63.1,52.19 63.11,52.2 63.12,52.2
  BOTTOM w0.102: U7.BH40 65.08,58.95 65.05,58.92 65.05,58.68 64.86,58.49 64.86,57.8 64.95,57.71 64.95,57.02 64.74,56.8 64.25,56.8 64.02,56.58 64.02,56.27 64.36,55.93 64.36,55.72 63.94,55.31 63.94,52.85 63.84,52.75 63.59,52.75 63.39,52.54 63.39,52.31 63.27,52.2 63.12,52.2
M_A_DQSP5: length 22.8
  TOP w0.089: v3(63.99,49.39) 63.79,49.19 63.62,49.19 63.31,48.88 63.31,48.64 62.9,48.23 62.89,48.23 62.53,47.87 62.43,47.87 62.35,47.96 U25.F3
  IN1 w0.076: 63.85,49.86 63.81,49.86 63.64,49.69 63.64,49.51 63.64,49.23 63.72,49.15 63.88,49.15 63.99,49.26 v3(63.99,49.39)
  IN1 w0.089: v1(68.47,64.95) 68.55,65.03 68.55,65.17 68.46,65.26 68.1,65.26 67.99,65.14 67.99,64.94 67.9,64.85 67.69,64.85 67.6,64.76 67.6,59.23 66.85,58.47 66.85,57.48 66.52,57.15 66.51,57.11 66.51,57.02 66.5,57.01
  IN1 w0.14: 63.85,49.86 64.48,50.49 64.78,50.49 65.54,51.24 65.77,51.48 65.77,52.03 65.77,52.21 65.67,52.31 65.67,53.53 65.76,53.62 65.76,56.27 66.5,57.01
  BOTTOM w0.089: U7.AT32 v1(68.47,64.95)
M_A_DQSP6: length 18.8
  IN2 w0.089: v3(64.74,48.24) 64.62,48.24 64.52,48.34 64.52,48.54 64.57,48.59 64.57,49.66 64.35,49.87 64.35,50.42 64.42,50.49 64.42,50.51 ; v1(69.46,61.39) 69.46,61.6 69.34,61.72 69.16,61.72 69.05,61.61 69.05,61.21 69.14,61.12 69.14,60.95 69.05,60.87 69.05,59.56 68.56,59.07 68.56,59.04 68.49,58.97 68.49,58.96 68.45,58.91
  IN2 w0.14: 64.42,50.51 64.42,50.86 64.7,51.13 64.7,51.91 64.76,51.97 64.76,53.38 64.91,53.53 64.91,53.95 66.83,55.87 66.83,56.32 67.04,56.53 68.17,57.66 68.17,58.59 68.17,58.63 68.45,58.91
  BOTTOM w0.089: U32.F3 65.59,48.13 65.59,47.94 65.51,47.87 65.42,47.87 64.55,47.87 64.47,47.96 64.47,48.01 64.7,48.24 v3(64.74,48.24) ; v1(69.46,61.39) U7.BC30
M_A_DQSP7: length 14.2
  TOP w0.076: U25.C7 65.26,50.86 65.06,50.86 64.83,50.62 64.51,50.62 64.27,50.86 64.27,51.46 64.51,51.7 64.51,52.48 64.76,52.74 64.98,52.74 65.17,52.93 65.17,53.17 65.47,53.47 66.51,53.47 66.66,53.62 67.76,53.62 67.79,53.65
  TOP w0.127: v1(68.96,55.58) 69.18,55.37 69.18,55.24 69.05,55.11 68.76,55.11 68.29,54.65 68.29,54.15 67.79,53.65
  BOTTOM w0.102: 68.87,57.57 68.87,58.35 68.95,58.43 68.95,58.44 68.95,58.45 68.95,58.92 68.97,58.94 U7.BH32
  BOTTOM w0.127: 68.87,57.57 68.8,57.51 68.8,56.35 69.34,55.81 69.34,55.62 69.22,55.49 69.06,55.49 v1(68.96,55.58)
M_A_DRAMRST#: length 78.2
  TOP w0.102: U25.T2 61.55,37.92 63.42,36.05 63.92,36.05 v1(64.31,36.43) ; U24.T2 43.77,37.64 45.46,35.95 46.16,35.95 v3(46.55,36.34)
  IN1 w0.089: 60.62,55.63 60.78,55.63 61.43,56.28 61.43,56.98 62.16,57.71 62.16,58.66 63.18,59.68 63.18,61.7 v1(63.59,62.1)
  IN1 w0.135: 60.62,55.63 58.51,55.63 58.11,55.23 57.21,55.23 56.77,54.8 56.77,54.1 56.35,53.69 56.35,53.3 54.59,51.54 54.59,50.34 53.8,49.56 53.8,49.54 53.8,49.27 53.8,49.27 53.8,46 54.64,45.16 54.64,44.33 55.38,43.59 55.99,43.59 56.25,43.33 56.25,42.96 57.23,41.99 57.23,40.95 57.7,40.48 57.7,36.64 56.71,35.65 v3(55.48,35.65)
  IN2 w0.102: v3(46.55,36.34) 46.55,36.13 47.38,35.3 55.13,35.3 v3(55.48,35.65) 63.53,35.65 v1(64.31,36.43)
  BOTTOM w0.089: U7.BA42 v1(63.59,62.1)
  BOTTOM w0.102: v1(64.31,36.43) 64.64,36.77 64.77,36.77 64.9,36.64 65.21,36.64 65.65,37.08 65.65,37.39 65.6,37.44 65.6,37.64 65.69,37.73 65.81,37.73 65.9,37.64 66.03,37.64 66.12,37.73 66.12,38.24 66.12,38.24 66.35,38.47 U32.T2 ; v3(46.55,36.34) 47.03,36.82 47.42,36.82 47.87,37.27 47.87,37.39 47.82,37.44 47.82,37.64 47.91,37.73 48.03,37.73 48.11,37.66 48.28,37.66 48.37,37.75 48.37,37.89 48.32,37.94 48.32,38.23 48.57,38.47 U31.T2
M_A_ODT0: length 88.1
  TOP w0.089: v3(64.64,45.35) 64.63,45.35 64.61,45.33 64.33,45.33 64.09,45.09 63.97,45.09 63.8,44.92 63.58,44.92 63.32,45.18 63.13,45.18 62.52,44.57 62.2,44.57 62.02,44.39 61.81,44.39 61.63,44.57 61.14,44.57 61,44.71 61,44.71 U25.K1 ; v1(45.82,45.25) 45.81,45.26 45.77,45.26 45.66,45.37 45.05,45.37 44.88,45.21 44.88,44.82 44.63,44.57 44.49,44.57 44.29,44.36 44.08,44.36 43.88,44.57 43.6,44.57 43.5,44.67 43.27,44.67 43.17,44.57 42.63,44.57 42.55,44.66 42.55,44.88 42.63,44.97 U24.K1 ; v1(66.56,63.53) 66.25,63.53 66.16,63.44 66.16,59.41 66.03,59.27 65.41,59.27 65.32,59.18 65.32,58.9 65.41,58.82 65.64,58.82 65.74,58.92 65.99,58.92 66.09,58.82 66.37,58.82 66.46,58.9 66.46,59.47 66.56,59.57 66.83,59.57 66.91,59.5 66.91,58.98
  TOP w0.117: 66.91,58.98 66.99,58.89 68.03,58.89 68.24,58.69 68.24,57.67 67.86,57.3 66.94,57.3 66.78,57.45 66.78,57.72 66.67,57.84 66.37,57.84 66.25,57.72 66.25,57.45 66.12,57.32 64.75,57.32 61.01,53.58 60.75,53.58 60.63,53.7 60.63,53.91 60.5,54.04 60.25,54.04 60.12,53.91 60.12,53.76 59.99,53.63 58.58,53.63 57.83,52.88 57.83,52.69 58.18,52.33 58.18,52.17 58.04,52.02 57.58,52.02 57.4,51.84 57.4,51.37 57.28,51.25 57.02,51.25 56.89,51.37 56.89,51.55 56.77,51.67 56.47,51.67 56.1,51.3 55.65,51.3 55.53,51.17 55.53,50 54.86,49.33 54.86,49.08 55.18,48.76 55.18,48.33 55.3,48.22 55.86,48.22 56.07,48.01 56.07,47.84 55.88,47.65 55.88,46.64 55.76,46.52 55.62,46.52 55.19,46.09 55.19,45.88 55.25,45.82 55.25,45.19 55.38,45.06 55.61,45.06 55.72,44.95 55.92,44.95 56.29,45.32 56.29,45.54 55.88,45.95 55.79,45.95 v1(55.78,45.96)
  IN2 w0.102: v3(64.64,45.35) 64.95,45.35 65.27,45.03 65.44,45.03 65.57,45.15 65.57,45.92 65.45,46.03 64.64,46.03 64.36,45.75 64.24,45.75 64.12,45.63 64.12,45.46 64,45.33 63.58,45.33 63.51,45.4 62.78,45.4 62.09,44.72 60.72,44.72 60.44,45 60.44,45.54 60.29,45.68 59.54,45.68 59.42,45.81 57.12,45.81 57.1,45.84 56.03,45.84 55.91,45.95 55.79,45.95 v1(55.78,45.96) 55.76,45.95 55.76,45.91 55.66,45.8 55.38,45.8 55.28,45.91 55.28,46.04 55.18,46.14 54.98,46.14 54.87,46.04 54.87,45.9 54.77,45.8 54.49,45.8 54.39,45.9 54.39,46.09 54.26,46.22 54.08,46.22 53.98,46.12 53.98,45.91 53.88,45.81 53.68,45.81 53.58,45.91 53.58,46.13 53.47,46.24 53.27,46.24 53.17,46.14 53.17,45.91 53.07,45.81 52.84,45.81 52.74,45.91 52.74,46.14 52.64,46.24 52.44,46.24 52.33,46.14 52.33,45.9 52.23,45.8 51.79,45.8 51.04,45.05 50.56,45.05 50.1,44.59 47.83,44.59 47.73,44.7 47.01,44.7 46.81,44.89 46.19,44.89 v1(45.82,45.25)
  BOTTOM w0.089: v1(45.82,45.25) 45.82,45.06 45.7,44.93 45.7,44.81 45.79,44.72 45.99,44.72 46.17,44.9 46.63,44.9 46.81,45.07 47.18,45.07 47.59,44.67 47.6,44.67 47.63,44.64 47.9,44.64 47.93,44.67 48.33,44.67 48.41,44.59 49.41,44.59 49.5,44.68 49.5,44.83 U31.K1 ; v3(64.64,45.35) 65.01,45.35 65.1,45.26 65.1,45.06 65.22,44.94 65.22,44.83 65.23,44.82 65.23,44.6 65.34,44.49 65.6,44.49 65.88,44.78 66.04,44.78 66.2,44.62 66.48,44.62 66.74,44.36 66.87,44.36 67.07,44.57 67.29,44.57 67.47,44.38 67.64,44.38 67.78,44.52 67.78,44.83 67.64,44.97 U32.K1 ; U7.AV36 v1(66.56,63.53)
  BOTTOM w0.117: R1073.2 55.35,47.11 55.35,46.39 v1(55.78,45.96)
M_A_RAS#: length 77
  TOP w0.089: v3(46.33,45.84) 46.33,46.21 46.24,46.3 46.02,46.3 45.93,46.39 45.93,46.84 45.82,46.94 45.52,46.94 45.29,46.71 45.29,46.52 45.37,46.44 45.47,46.44 45.56,46.35 45.56,46.12 45.27,45.83 44.91,45.83 44.83,45.9 44.7,45.9 U24.J3 ; U25.J3 62.12,46 62.12,46.15 62.2,46.24 62.95,46.24 63.11,46.4 63.11,46.89 63.2,46.98 63.48,46.98 63.56,46.89 63.56,46.47 63.79,46.24 64.11,46.24 v3(64.2,46.15) ; v1(64.58,62.1) 64.94,61.75 65.3,61.75 65.39,61.65 65.39,61.39 65.32,61.31 65.03,61.31 64.95,61.24 64.95,60.98 65.05,60.89 65.36,60.89 65.44,60.81 65.44,60.59 65.36,60.52 65.04,60.52 64.94,60.42 64.94,60.27 65.16,60.04 65.16,59.82 64.59,59.25 64.38,59.25 63.8,58.67 63.8,58.51 64.03,58.28
  TOP w0.117: v1(54.93,46.8) 54.63,46.5 54.43,46.5 54.31,46.63 54.31,49.34 54.31,49.34 54.31,49.57 54.97,50.23 54.97,51.62 55.09,51.75 55.21,51.75 55.33,51.87 55.33,52.05 54.81,52.57 54.81,52.78 54.98,52.95 55.16,52.95 55.67,52.44 55.87,52.44 56.04,52.6 56.04,52.78 55.53,53.29 55.53,53.5 55.7,53.67 55.88,53.67 56.57,52.97 56.69,52.97 56.8,53.09 57.22,53.09 57.7,53.57 57.7,53.74 57.47,53.97 56.88,53.97 56.8,54.04 56.8,54.22 57.18,54.6 57.18,54.74 57.31,54.88 57.49,54.88 57.77,54.6 57.97,54.6 58.24,54.87 58.42,54.87 58.75,54.55 61.09,54.55 63.32,56.78 63.32,57.47 63.48,57.63 64.05,57.63 64.24,57.81 64.24,58.07 64.03,58.28
  IN2 w0.102: v3(46.33,45.84) 46.54,45.84 47.28,45.1 47.9,45.1 48,45 48.31,45 48.5,45.19 48.62,45.19 48.82,45 49.21,45 49.35,45.14 49.35,45.52 49.41,45.57 49.61,45.57 49.71,45.47 49.71,45.17 49.8,45.08 49.95,45.08 50.32,45.46 50.58,45.46 51.88,46.76 52.31,46.76 52.39,46.84 52.39,47.27 52.54,47.42 52.69,47.42 52.82,47.28 52.82,46.78 52.9,46.7 53.14,46.7 53.23,46.79 53.23,47.4 53.33,47.5 53.52,47.5 53.64,47.38 53.64,46.81 53.74,46.71 53.94,46.71 54.04,46.81 54.04,47.33 54.16,47.45 54.34,47.45 54.45,47.35 54.45,46.9 54.55,46.8 v1(54.93,46.8) 54.93,47.06 54.86,47.13 54.86,47.33 55.04,47.52 55.61,47.52 55.67,47.46 55.89,47.46 55.98,47.38 55.98,47.12 55.92,47.06 55.57,47.06 55.42,46.92 55.42,46.74 55.53,46.64 55.97,46.64 56.17,46.84 56.52,46.84 56.53,46.84 56.68,46.84 57.05,47.22 57.12,47.22 57.53,46.81 57.69,46.81 57.95,47.07 58.1,47.07 58.35,46.82 58.35,46.71 58.44,46.61 58.44,46.51 58.35,46.41 58.35,46.28 58.41,46.22 59.59,46.22 59.71,46.09 60.05,46.09 60.19,46.23 60.32,46.23 60.83,45.72 60.98,45.72 61.2,45.94 61.33,45.94 61.55,45.72 61.72,45.72 61.95,45.95 62.21,45.95 62.39,45.78 62.53,45.78 62.62,45.86 63.15,45.86 63.23,45.94 63.39,45.94 63.54,46.09 63.54,46.25 63.65,46.36 63.79,46.36 63.83,46.32 64.04,46.32 v3(64.2,46.15)
  BOTTOM w0.089: U32.J3 65.58,45.8 65.58,46.04 65.49,46.12 65.49,46.18 65.31,46.36 65.18,46.36 65.09,46.27 65.09,46.04 65,45.95 64.77,45.95 64.68,46.04 64.68,46.25 64.77,46.34 64.77,46.59 64.68,46.69 64.68,46.83 64.58,46.93 64.46,46.93 64.37,46.84 64.37,46.31 v3(64.2,46.15) ; v3(46.33,45.84) 46.09,46.08 46.09,46.21 46.19,46.3 46.49,46.3 46.63,46.15 46.76,46.15 47.08,46.47 47.4,46.47 47.63,46.24 47.9,46.24 48.08,46.43 48.17,46.43 48.38,46.23 48.38,46.04 48.17,45.84 47.84,45.84 U31.J3 ; U7.BA40 v1(64.58,62.1)
  BOTTOM w0.117: v1(54.93,46.8) 54.69,46.8 R1064.2
M_A_WE#: length 68
  TOP w0.089: v3(46.57,44.3) 46.49,44.38 45.58,44.38 45.25,44.05 44.68,44.05 U24.L3 ; U25.L3 62.55,44.38 63.09,44.38 63.65,43.81 63.79,43.81 63.89,43.91 63.89,44.04 63.54,44.39 v3(63.54,44.54)
  TOP w0.117: R1060.2 56.98,44.66 v1(57.19,44.87)
  IN1 w0.135: v1(57.19,44.87) 57.19,45.16 57.37,45.33 58.03,45.33 58.82,44.54 59.4,44.54 59.68,44.82 59.68,45.46 59.44,45.7 59.01,45.7 58.9,45.59 58.65,45.59 58.4,45.84 58.4,46.09 58.58,46.28 58.58,46.53 58.21,46.9 57.86,46.9 57.69,46.73 57.69,46.12 57.51,45.94 57.15,45.94 56.97,46.12 56.97,46.7 56.76,46.91 56.76,47.38 56.53,47.61 56.07,47.61 55.56,48.12 55.36,48.12 55.18,48.3 55.18,48.65 55.36,48.83 55.56,48.83 55.74,49.01 55.74,49.39 55.93,49.58 55.93,50.56 57.3,51.93 57.55,51.93 v1(57.87,51.6)
  IN2 w0.102: v3(63.54,44.54) 63.6,44.54 63.79,44.73 63.79,44.83 63.7,44.92 63.42,44.92 63.34,44.99 62.96,44.99 62.28,44.31 62.08,44.31 61.94,44.17 61.65,44.17 61.51,44.31 60.97,44.31 60.83,44.17 60.38,44.17 60.24,44.31 60.09,44.31 59.99,44.41 59.99,45.19 59.91,45.28 59.66,45.28 59.6,45.22 59.6,44.64 59.49,44.53 58.84,44.53 58.46,44.15 58.46,44.03 58.36,43.93 57.63,43.93 57.22,44.34 56.99,44.34 56.83,44.5 56.83,44.67 57.03,44.87 v1(57.19,44.87) 57.19,45.17 57.05,45.31 56.71,45.31 56.67,45.34 56.33,45.34 56.3,45.31 54.63,45.31 54.59,45.35 51.92,45.35 51.21,44.64 50.89,44.64 50.43,44.19 47.66,44.19 47.56,44.29 46.59,44.29 v3(46.57,44.3)
  BOTTOM w0.089: U32.L3 65.55,43.98 65.46,43.89 65.32,43.89 65.05,44.16 64.92,44.16 64.69,44.39 64.6,44.39 64.5,44.49 64.5,44.59 64.47,44.62 64.47,44.7 64.31,44.87 63.86,44.87 v3(63.54,44.54) ; v1(57.87,51.6) 57.47,51.2 57.3,51.2 56.59,50.48 55.2,50.48 55.1,50.59 55.1,50.77 55.22,50.89 56.43,50.89 56.97,51.43 56.97,51.47 57.62,52.12 58.22,52.12 58.31,52.03 58.48,52.03 58.62,52.17 58.62,52.31 58.56,52.38 58.56,52.52 58.69,52.66 58.85,52.66 58.91,52.6 59.05,52.6 59.2,52.74 59.2,52.89 59.15,52.93 59.15,53.09 59.27,53.21 59.45,53.21 59.49,53.18 59.63,53.18 59.77,53.32 59.77,53.46 59.75,53.49 59.75,53.63 60.16,54.04 60.91,54.04 60.94,54.07 61.18,54.07 62.07,54.95 62.07,56.89 62.82,57.64 62.82,58.09 63.01,58.28 63.01,58.3 63.04,58.33 63.14,58.43 U7.BH44 ; U31.L3 47.85,44.25 47.85,44.37 47.76,44.45 47.55,44.45 47.54,44.46 47.53,44.46 47.31,44.67 47.19,44.67 47.11,44.6 46.99,44.6 46.88,44.7 46.57,44.7 46.47,44.6 46.47,44.41 v3(46.57,44.3)
M_A_ZQ1: length 5
  BOTTOM w0.102: U31.L8 43.38,43.78 42.24,43.78 42.04,43.99
  BOTTOM w0.108: R1045.2 41.76,44.27 42.04,43.99
M_A_ZQ2: length 9.8
  TOP w0.117: U24.L8 48.98,43.75 50.85,43.75 51.33,43.28 51.33,38.09 50.75,37.51 R1046.2
M_A_ZQ3: length 5.5
  BOTTOM w0.102: R1047.2 57.32,42.11 58.96,43.75 61.13,43.75 U32.L8
M_A_ZQ4: length 5.3
  TOP w0.102: U25.L8 66.76,43.75 67.7,43.75 68.32,43.14 68.69,42.77 R1048.2
M_B_A0: length 67.8
  TOP w0.089: U27.N3 97.52,42.44 97.94,42.44 98.2,42.18 98.2,41.93 98.38,41.75 98.8,41.75 99.18,42.14 v3(99.29,42.14) ; v3(81.76,42.15) 81.56,41.95 81.29,41.95 81.22,41.88 80.87,41.88 80.53,42.22 80.5,42.25 79.94,42.25 79.62,42.57 U26.N3
  IN1 w0.089: 84.3,59.01 84.18,59.12 84.07,59.12 83.99,59.05 83.99,58.45 83.89,58.35 83.77,58.35 83.69,58.43 83.69,59.05 83.61,59.12 83.46,59.12 83.38,59.05 83.38,58.6 83.3,58.51 83.16,58.51 83.08,58.59 83.08,59.05 83,59.12 82.85,59.12 82.77,59.05 82.77,58.6 82.69,58.51 82.55,58.51 82.47,58.59 82.47,59.05 82.39,59.12 82.24,59.12 82.16,59.05 82.16,58.75 82.09,58.67 81.94,58.67 81.86,58.75 81.86,59.05 81.78,59.12 81.47,59.12 80.6,59.99 80.6,60.14 80.59,60.14 80.59,60.52 80.6,60.53 80.6,60.63 80.68,60.71 81.02,60.71 81.09,60.78 81.09,60.93 81.01,61.01 80.68,61.01 80.6,61.09 80.6,61.22 80.69,61.31 81.4,61.31 81.5,61.41 v1(81.5,61.71)
  IN1 w0.135: v1(92.06,41.82) 92.06,42.35 92.51,42.79 92.51,43.05 92.28,43.28 92.28,44.13 92.39,44.24 92.39,45.79 92.39,45.79 92.39,47.04 92.05,47.38 92.05,48.02 92.58,48.55 92.58,49.78 92.3,50.06 92.3,51.91 89.11,55.09 88.38,55.09 88.09,55.38 87.91,55.38 87.73,55.21 87.14,55.21 87.1,55.25 86.72,55.25 85.94,56.03 85.94,56.41 85.71,56.64 85.38,56.64 85.13,56.9 85.13,58.67 84.79,59.01 84.3,59.01
  IN2 w0.089: 83.24,42.15 v3(81.76,42.15)
  IN2 w0.102: v3(99.29,42.14) 99.44,42.28 100,42.28 100.1,42.19 100.1,41.99 99.84,41.73 99.47,41.73 99.44,41.75 99.13,41.75 99.1,41.73 97.74,41.73 97.5,41.49 96.86,41.49 96.35,40.98 95.81,40.98 95.79,40.95 95.4,40.95 95.32,41.03 94.74,41.03 94.61,40.91 94.11,40.91 93.96,41.05 93.96,41.24 93.86,41.34 93.66,41.34 93.56,41.24 93.56,41.05 93.45,40.95 93.25,40.95 92.38,41.82 v1(92.06,41.82) 90.26,41.82 90.08,41.65 89.41,41.65 89.31,41.54 86.78,41.54 86.37,41.95 83.44,41.95 83.24,42.15
  BOTTOM w0.089: v3(99.29,42.14) 99.25,42.18 99.06,42.18 98.97,42.27 98.97,42.49 99.06,42.57 99.44,42.57 99.76,42.26 100.09,42.26 100.4,42.57 100.6,42.57 U33.N3 ; v1(81.5,61.71) 81.24,61.97 U7.BB7 ; v3(81.76,42.15) 81.6,42.15 81.44,42.31 81.44,42.51 81.59,42.66 82.1,42.66 82.29,42.85 82.71,42.85 82.82,42.74 U34.N3
  BOTTOM w0.117: v1(92.06,41.82) 91.51,41.27 91.51,41.22 R1091.2
