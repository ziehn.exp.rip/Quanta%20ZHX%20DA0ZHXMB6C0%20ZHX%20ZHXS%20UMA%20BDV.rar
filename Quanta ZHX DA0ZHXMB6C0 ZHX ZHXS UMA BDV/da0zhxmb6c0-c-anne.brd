# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VGG_SENSEN_R: length 24.5
  IN2 w0.102: 75.01,74.01 73.48,72.48 73.48,72.05 73.58,71.95 73.58,71.75 v1(74.05,71.28)
  IN2 w0.254: 75.01,74.01 75.16,74.16 76.71,74.16 76.85,74.02 84.16,74.02 84.53,74.38 88.01,74.38 88.52,74.89 91.97,74.89 v1(92.28,74.59)
  BOTTOM w0.102: v1(74.05,71.28) 73.67,70.91 U7.AD22
  BOTTOM w0.254: R188.2 92.79,75.51 92.33,75.05 92.33,74.64 v1(92.28,74.59)
VGG_SENSEP: length 23
  TOP w0.254: PR213.1 110.36,63.09 110.36,63.55 109.65,64.26 v1(109.06,64.26)
  BOTTOM w0.254: R191.1 96.02,73.4 96.38,73.76 97.53,73.76 100.38,70.91 103.47,70.91 104.76,69.61 107.95,69.61 109.32,68.23 109.32,64.52 v1(109.06,64.26)
VGG_SENSEP_R: length 26
  IN2 w0.102: v1(73.3,71.28) 73.21,71.37 73.21,72.73 75.01,74.53
  IN2 w0.254: v1(92.97,74.84) 92.89,74.92 92.89,75.07 92.43,75.53 88.41,75.53 87.64,74.76 84.29,74.76 83.91,74.38 77,74.38 76.81,74.56 75.04,74.56 75.01,74.53
  BOTTOM w0.102: U7.AD24 72.92,70.91 v1(73.3,71.28)
  BOTTOM w0.254: R191.2 94.04,73.85 93.35,73.85 92.97,74.23 v1(92.97,74.84)
VGPU_EN: length 4.3
  TOP w0.089: 81.09,73.72 v1(80.8,73.43)
  TOP w0.108: 81.09,73.72 81.22,73.85 83.97,73.85 TP28.1
  BOTTOM w0.102: U7.Y7 80.8,73.29 v1(80.8,73.43)
VL: length 132
  TOP w0.508: v1(146.51,96.36) 146.51,95.68 145.47,94.64 PR145.2
  IN1 w0.508: v1(153.63,41.52) 153.11,42.04 153.11,56.3 152.45,56.97 152.45,68.31 150.06,70.7 148.91,70.7 148.1,71.51 148.1,73.92 146.55,75.47 146.55,76.63 145.9,77.28 145.9,79.14 145.69,79.36 145.69,83.19 146.15,83.65 146.15,91.61 145.11,92.65 145.11,94.33 146.51,95.72 v1(146.51,96.36) 146.08,96.79 144.55,96.79 141.82,94.06 138.42,94.06 137.42,93.06 132.47,93.06 131.7,93.83 131.7,94.5 131.67,94.53 v1(131.67,94.58) ; v1(123.16,42.65) 122.81,42.3 122.81,40.76 122.43,40.38 120.3,40.38 119,39.08 116.97,39.08 116.68,39.37 v1(116.68,39.98)
  IN2 w0.508: v1(153.63,41.52) 152.25,40.14 145.18,40.14 143.51,38.46 139.03,38.46 138.2,37.63 137.31,37.63 137.21,37.73 130.43,37.73 129.94,37.24 129.29,37.24 128.28,38.25 128.28,39.09 127.23,40.13 126.31,40.13 123.79,42.65 v1(123.16,42.65)
  BOTTOM w0.203: PU3.11 131.78,94.69 v1(131.67,94.58)
  BOTTOM w0.508: PR14.1 116.3,40.36 v1(116.68,39.98) ; PC51.2 130.57,94.58 v1(131.67,94.58) ; PR15.1 122.63,42.65 v1(123.16,42.65)
VNN_REFIN_R: length 29.5
  IN1 w0.089: 73.73,72.47 72.69,72.47 72.68,72.48 71.4,72.48 v1(71.02,72.1)
  IN1 w0.14: v1(96.67,71.16) 96.67,71.69 95.84,72.53 94.29,72.53 94.16,72.66 81.18,72.66 80.93,72.91 78.41,72.91 78.3,73.02 75.53,73.02 75.23,73.32 74.65,73.32 73.8,72.47 73.73,72.47
  BOTTOM w0.102: v1(71.02,72.1) 71.02,72.07 71.4,71.69 U7.AC27
  BOTTOM w0.108: v1(96.67,71.16) 96.98,71.47 96.98,71.94 R169.2
VOL_DN#: length 96.8
  TOP w0.108: v1(140.41,79.34) 140.41,79.67 140.59,79.85 140.59,79.87 141.05,80.33 141.05,80.56 141.37,80.88 141.37,81.38 141.56,81.57 141.56,83.89 141.37,84.07 141.37,84.56 141.02,84.92 141.02,86.27 142.34,87.59 145.97,87.59 146.36,87.98 146.36,94.61 v1(146.8,95.05) 147.37,95.62 147.37,99.05 146.81,99.61 v1(146.81,99.84) ; v1(134.59,25.05) 134.38,25.05 133.9,24.57 U9.47
  IN1 w0.14: v1(134.59,25.05) 136.79,25.05 138.95,27.21 138.95,30.75 139.55,31.36 139.55,33.91 140.58,34.94 141.09,34.94 141.49,35.34 141.49,38.34 141.11,38.71 141.11,39.58 142.25,40.71 142.25,41.9 142.47,42.12 145.59,42.12 147.4,43.93 147.4,49 147.73,49.33 147.73,56.25 148.77,57.29 148.77,59.35 148.31,59.81 148.31,65.07 144.73,68.65 144.73,71.69 142.26,74.16 142.26,77.76 140.69,79.34 v1(140.41,79.34)
  BOTTOM w0.108: v1(146.81,99.84) 146.81,99.91 146.65,100.08 CN3.11
VOL_UP#: length 81.9
  TOP w0.108: U9.124 129.9,40.37 129.57,40.7 129.57,42.1 129.32,42.35 129.32,44.19 v1(129.43,44.3) ; v1(136.08,73.33) 135.26,74.16 135.26,74.32 135.59,74.66 136.11,74.66 136.27,74.51 137.38,74.51 137.44,74.56 137.95,75.08 137.98,75.1 137.98,75.11 138.06,75.18 138.06,76.64 139.08,77.67 139.08,78.09 139.9,78.91 140.74,78.91 140.86,79.03 140.86,79.84 141.28,80.25 141.28,80.46 141.58,80.76 141.58,81.27 141.78,81.47 141.78,83.96 141.61,84.14 141.61,84.65 141.25,85 141.25,86.17 142.38,87.3 145.99,87.3 146.57,87.89 146.57,94.1 147.63,95.16 147.63,99.48 v1(147.45,99.66)
  IN2 w0.14: v1(136.08,73.33) 136.6,72.81 136.6,70.47 138.51,68.56 138.51,68.15 139.72,66.94 139.72,63.96 140.56,63.12 140.56,56.23 139.03,54.69 138.19,54.69 136.52,53.03 135.6,53.03 133.19,50.62 133.19,49.4 133.15,49.36 133.15,46.43 133.2,46.38 133.2,45.5 132.8,45.11 132.8,44.62 131.75,43.57 130.42,43.57 130.11,43.88 129.85,43.88 v1(129.43,44.3)
  BOTTOM w0.108: v1(147.45,99.66) 147.45,99.94 147.15,100.24 CN3.10
VR_READY_VCORE: length 3.7
  BOTTOM w0.203: 38.86,68.05 39.18,68.05 39.29,67.93 PU4.17
  BOTTOM w0.254: PR38.1 37.45,69.54 38.04,68.94 38.04,68.51 38.51,68.05 38.86,68.05
VR_READY_VGG: length 3.8
  TOP w0.203: PU6.17 124.34,55.1 124.71,55.47 124.71,55.82 125.34,56.45 v1(126.18,56.45) PR65.2
VR_SVID_ALERT#: length 134.3
  TOP w0.102: v1(35.45,66.75) 35.86,66.34 38.13,66.34 38.76,66.97 41.75,66.97 42.18,66.54 43.41,66.54 44.05,67.18 44.05,69.46 42.7,70.81 42.7,71.9 v1(42.72,71.92) ; PR73.1 v1(128.37,54.36)
  IN2 w0.089: 77.14,66.67 77.62,67.15 83.62,67.15 83.98,67.52 86.47,67.52 86.6,67.65 91.45,67.65 91.62,67.48
  IN2 w0.102: 61.24,68.37 61.44,68.37 61.81,68 62.83,68 63.25,68.42 64.47,68.42 65.5,67.39 73.67,67.39 74.39,66.67 77.14,66.67
  IN2 w0.14: 91.62,67.48 92.77,66.33 93.78,66.33 93.79,66.33 94.12,66.33 103.15,57.29 103.15,57.2 105.02,55.33 105.02,53.26 107.34,50.94 v1(107.34,50.64) ; v1(42.72,71.92) 42.72,70.98 44.48,69.23 45.7,69.23 46.55,68.38 48.23,68.38 48.55,68.7 53.24,68.7 54.26,67.68 58.52,67.68 59.21,68.37 61.24,68.37
  BOTTOM w0.102: v1(35.45,66.75) 36.03,67.34 PR36.1 ; R143.2 43.55,70.99 42.72,71.82 v1(42.72,71.92) ; v1(107.34,50.64) 106.96,50.26 106.96,49.77 107.21,49.52 107.54,49.52 107.77,49.75 110.56,49.75 111.71,50.89 113.36,50.89 115.09,49.16 115.91,49.16 116.71,48.36 116.71,47.54 117.81,46.45 118.1,46.45 119.51,45.03 124.21,45.03 124.55,44.69 125.59,44.69 126.74,45.84 126.74,48.75 128.66,50.67 130.46,50.67 131.47,51.69 131.47,53.6 130.94,54.13 128.59,54.13 v1(128.37,54.36)
VR_SVID_CLK: length 140.2
  TOP w0.102: PR62.2 128.99,54.56 128.37,55.19 v1(128.37,55.43) 128.09,55.43 128.06,55.4 PR69.1 ; v1(42.75,72.63) 42.22,72.1 42.22,70.61 43.56,69.26 43.56,67.38 43.21,67.02 42.38,67.02 41.95,67.45 39.19,67.45 38.56,68.08 38.23,68.08 38.1,67.95 38.1,67.15 37.77,66.82 36.48,66.82 36.03,67.26 PR44.1 35.24,67.44 35.23,67.43 PR187.2
  IN2 w0.089: 76.46,66.9 76.87,66.9 77.22,67.25 77.22,67.66 77.67,68.11 83.51,68.11 83.92,67.7 86.33,67.7 86.46,67.83 91.59,67.83 91.82,67.61
  IN2 w0.102: 47.85,68.9 47.89,68.9 ; 61.44,68.66 61.83,68.27 62.66,68.27 63.12,68.72 64.69,68.72 65.74,67.68 73.82,67.68 74.6,66.9 76.46,66.9
  IN2 w0.14: 91.82,67.61 92.81,66.61 94.24,66.61 103.02,57.84 103.29,57.84 105.55,55.58 105.55,53.48 107.87,51.15 107.87,50.29 108.05,50.11 108.05,49.34 v1(107.82,49.11) ; 47.89,68.9 48.12,69.13 53.45,69.13 54.49,68.09 58.19,68.09 58.77,68.66 61.44,68.66 ; 47.85,68.9 46.76,68.9 45.91,69.75 44.69,69.75 43.61,70.83 43.61,71.69 42.75,72.56 v1(42.75,72.63)
  BOTTOM w0.102: v1(128.37,55.43) 129.16,54.63 131.95,54.63 132.42,54.16 132.42,51.94 130.67,50.19 128.86,50.19 127.22,48.55 127.22,45.64 125.79,44.21 124.35,44.21 124.01,44.55 119.31,44.55 117.9,45.96 117.61,45.96 116.23,47.34 116.23,48.16 115.74,48.66 114.91,48.66 113.3,50.27 113.03,50.27 112.89,50.41 111.91,50.41 110.72,49.23 107.94,49.23 v1(107.82,49.11) ; R148.2 43.44,71.9 42.75,72.58 v1(42.75,72.63)
VR_SVID_DATA: length 136.4
  TOP w0.102: v1(35.36,66.11) 35.43,66.03 38.28,66.03 38.94,66.69 41.63,66.69 42.06,66.26 43.52,66.26 44.35,67.08 44.35,68.38 v1(44.72,68.75) ; PR79.1 128.99,52.4 128.37,53.02 v1(128.37,53.29) PR76.2
  IN2 w0.089: 91.39,67.3 91.24,67.46 86.7,67.46 86.57,67.33 84.04,67.33 83.69,66.97 77.76,66.97 77.2,66.41
  IN2 w0.102: 61.01,68.06 61.34,68.06 61.78,67.62 63.05,67.62 63.51,68.09 64.3,68.09 65.31,67.08 73.63,67.08 74.3,66.41 77.2,66.41
  IN2 w0.14: 61.01,68.06 59.35,68.06 58.64,67.35 54.09,67.35 53.1,68.34 48.82,68.34 48.54,68.06 46.41,68.06 45.72,68.75 v1(44.72,68.75) ; v1(107.39,49.95) 107.06,49.95 106.83,50.18 106.83,51 104.71,53.13 104.71,55.02 102.76,56.98 102.76,57.31 94.06,66 92.69,66 91.39,67.3
  BOTTOM w0.102: v1(44.72,68.75) 44.72,68.75 43.73,68.75 43.55,68.92 R139.2 ; v1(128.37,53.29) 128.37,53.63 128.59,53.85 130.82,53.85 131.19,53.48 131.19,51.87 130.39,51.07 128.5,51.07 126.34,48.91 126.34,45.84 125.47,44.97 124.67,44.97 124.32,45.31 119.62,45.31 118.21,46.73 117.92,46.73 116.99,47.65 116.99,48.48 116,49.47 115.18,49.47 114.67,49.97 114.67,51.94 114.57,52.04 114.36,52.04 114.26,51.94 114.26,51.32 114.16,51.22 113.97,51.22 113.86,51.32 113.86,52.6 113.76,52.7 113.53,52.7 113.43,52.6 113.43,51.32 113.28,51.17 113.14,51.17 112.99,51.32 112.99,52.55 112.89,52.64 112.69,52.64 112.58,52.54 112.58,51.32 112.43,51.17 111.59,51.17 110.45,50.03 107.47,50.03 v1(107.39,49.95) ; PR42.2 36.03,66.2 35.94,66.11 v1(35.36,66.11) 34.99,66.47 PR188.1
VRON_VCORE: length 7.9
  TOP w0.254: PR235.1 PC135.2 44.32,70.15 44.7,69.77 PR154.1 44.71,69.56 45.39,68.88 45.39,68.13 v1(45.24,67.98)
  BOTTOM w0.203: 43.55,66.75 43.33,66.52 PU4.26
  BOTTOM w0.254: v1(45.24,67.98) 45.23,67.97 PR234.2 44.13,67.97 43.69,67.53 43.69,66.88 43.55,66.75
VRON_VGG: length 4.4
  TOP w0.203: PR236.1 119.17,54.02 119.94,54.02 120.29,53.67 PU6.26
  TOP w0.254: v1(119.48,54.7) 119.44,54.67 PC154.2 PR236.1
  BOTTOM w0.254: PR195.2 v1(119.48,54.7)
WAKE_SRC_1: length 61
  TOP w0.108: v1(132.29,70.81) 132.6,71.13 v1(132.87,71.13) 139.12,71.13 142.69,74.69 R351.1
  IN2 w0.14: v1(132.29,70.81) 132.75,71.27 132.75,72.51 131.19,74.07 129.12,74.07 128.09,75.1 124.12,75.1 124.12,75.09 122.64,75.09 121.95,74.41 119.15,74.41 118.85,74.11 118.53,74.11 118.21,74.42 116.13,74.42 115.26,73.54 114.08,73.54 113.07,72.54 v1(112.87,72.54)
  BOTTOM w0.108: v1(112.87,72.54) 112.55,72.54 111.02,74.06 106.68,74.06 105,75.74 104.04,75.74 102.49,77.28 102,77.28 100.41,78.87 99.48,78.87 98.65,79.71 98.27,79.71 96.97,81.01 95.91,81.01 95.79,81.13 U17.3 95.33,80.96 94.21,80.96 94.02,81.15 R231.2
WIFI_SUSCLK: length 2.6
  TOP w0.076: 159.59,99.5 CN5.50
  TOP w0.108: TP46.1 158.66,99.5 159.59,99.5
WLAN_WAKE#: length 84.5
  TOP w0.108: v1(132.28,68.83) v1(133.19,69.74) 134.26,70.8 139.11,70.8 143.71,75.4 R360.1 ; U9.16 125.93,31.9 125.61,31.59 R235.1 124.34,30.78 123.17,29.61 v1(123.17,29.57)
  IN2 w0.14: v1(132.28,68.83) 132.28,68.83 131.49,68.83 130.46,67.8 129.68,67.8 129.21,68.27 129.21,68.76 128.75,69.21 127.97,69.21 127.71,68.95 127.71,68.52 127.26,68.08 124.96,68.08 124.61,67.73 122.63,67.73 122.09,67.19 121.48,67.19 121.17,66.89 116.09,66.89 112.92,63.72 112.92,62.09 114.2,60.81 114.2,57.78 115.29,56.69 115.29,53.01 116.16,52.15 116.16,50.4 115.84,50.08 115.84,49.39 116.5,48.73 116.5,45.97 116.77,45.7 116.77,41.75 115.03,40.01 115.03,35.55 118.37,32.22 118.37,31.64 119.66,30.34 121.33,30.34 121.58,30.09 122.63,30.09 123.11,29.61 123.13,29.61 v1(123.17,29.57)
WRST#: length 49
  TOP w0.203: 125.75,32.7 U9.14
  TOP w0.254: v1(144.38,35.03) 144.6,34.81 146.48,34.81 147.13,34.15 147.15,34.15 147.18,34.13 148.24,34.13 v1(149.37,35.25) 149.96,35.25 151.77,37.06 R1038.1 ; 125.75,32.7 124.63,32.7 C290.1 123.86,32.5 122.34,32.5 121.83,33.01 121.83,33.62 121.21,34.23 D16.2 120.85,35.55 120.43,35.13 R468.1 119.04,35.13 v1(118.85,35.32)
  IN2 w0.254: v1(118.85,35.32) 121.41,37.88 122.45,37.88 122.76,37.58 122.76,37.31 123.4,36.66 123.42,36.66 125.65,34.43 127.94,34.43 128.27,34.77 131.82,34.77 132.23,34.36 138.56,34.36 139.36,35.16 144.25,35.16 v1(144.38,35.03)
XD_CD#: length 2.4
  BOTTOM w0.108: U23.7 30.71,27.25 TP50.1
XD_D7: length 4.8
  BOTTOM w0.108: U23.23 23.54,26.75 23.45,26.84 22.02,26.84 21.36,26.18 21.36,24.92 TP37.1
XD_RE#: length 1.5
  BOTTOM w0.108: U23.9 29.87,26.25 TP51.1
XDP_H_PRDY#: length 1.6
  TOP w0.108: TP33.1 62.71,71.62 v1(62.71,71.45)
  BOTTOM w0.108: U7.AD45 62.36,71.1 v1(62.71,71.45)
XDP_H_PREQ#: length 16.8
  IN2 w0.102: 53.21,69.66 53.68,69.66 53.73,69.71 54.1,69.71 54.81,69 61.37,69 61.77,69.41 62.66,69.41 62.94,69.13 63.7,69.13 v1(64.14,69.56)
  IN2 w0.14: 53.21,69.66 51,69.66 50.61,70.05 50.24,70.05 v1(49.77,69.59)
  BOTTOM w0.102: U7.AF41 64.49,69.92 v1(64.14,69.56)
  BOTTOM w0.108: R356.1 49.54,69.82 v1(49.77,69.59)
XDP_H_TCK: length 20.7
  IN2 w0.102: v1(63.37,69.56) 62.7,70.23 58.97,70.23 58.64,69.91 56.93,69.91 56.31,70.52 54.46,70.52
  IN2 w0.14: 54.46,70.52 51.33,70.52 50.83,71.02 48.71,71.02 v1(47.12,69.43)
  BOTTOM w0.102: v1(63.37,69.56) 63.37,69.59 63.78,69.99 U7.AF42
  BOTTOM w0.108: v1(47.12,69.43) 47.12,68.75 47.37,68.49 47.86,68.49 R409.1
XDP_H_TDI: length 12.8
  TOP w0.108: R115.1 51.63,72.47 v1(51.84,72.69)
  IN2 w0.102: 59.35,71.37 59.67,71.05 61.6,71.05 v1(62,71.45)
  IN2 w0.14: 59.35,71.37 59.05,71.67 58.48,71.67 56.42,71.67 56.11,71.35 55.32,71.35 54.8,71.87 52.4,71.87 51.84,72.43 v1(51.84,72.69)
  BOTTOM w0.108: v1(62,71.45) 61.65,71.1 U7.AD47
XDP_H_TDO: length 18.3
  TOP w0.108: R357.1 52.2,74.08 v1(52.81,73.47)
  IN2 w0.102: 57.39,72.72 57.61,72.94 58.09,72.94 58.74,72.29 60.36,72.29 60.73,71.93 62.04,71.93 62.18,72.07 65.1,72.07 65.33,71.83 65.64,71.83 65.95,71.52 65.95,70.65 v1(64.85,69.55)
  IN2 w0.14: 57.39,72.72 55.05,72.72 54.79,72.97 53.31,72.97 v1(52.81,73.47)
  BOTTOM w0.102: v1(64.85,69.55) 65.2,69.9 U7.AF40
XDP_H_TMS: length 11.3
  TOP w0.108: v1(52.73,72.82) 52.41,72.82 51.18,74.06 R358.1
  IN2 w0.102: 56.89,72.48 57.28,72.09 58.65,72.09 58.65,72.09 59.94,72.09 v1(60.58,71.45)
  IN2 w0.14: v1(52.73,72.82) 52.96,72.6 54.83,72.6 54.95,72.48 56.89,72.48
  BOTTOM w0.108: v1(60.58,71.45) 61,71.04 U7.AD48
XDP_H_TRST#: length 1.7
  TOP w0.108: v1(61.29,71.45) 61.29,71.63 R113.2
  BOTTOM w0.108: v1(61.29,71.45) 60.94,71.81 U7.AB48
XIN: length 6.4
  BOTTOM w0.102: U35.10 29.08,59.78 C807.1 29.58,59.08 30.07,58.59 30.4,58.59 30.74,58.26 30.74,57.06 Y4.1
XOUT: length 3.7
  BOTTOM w0.102: U35.11 28.58,59.28 C806.1 29.63,58.22 Y4.3
XTAL25_IN: length 14.3
  IN2 w0.14: v1(72.33,76.01) 71.53,76.81 71.53,81.55 71.78,81.81 71.78,84.42 v1(71.98,84.62)
  BOTTOM w0.102: U7.P24 72.64,75.7 v1(72.33,76.01) ; Y2.3 70.59,87.83 C139.1 70.61,86.72 R311.1 71.32,85.56 v1(71.35,85.54) 71.98,84.9 v1(71.98,84.62)
XTAL25_OUT: length 16.1
  IN2 w0.14: v1(73.33,77.48) 71.88,78.93 71.88,81.35 72.25,81.71 72.25,83.87 v1(72.49,84.12)
  BOTTOM w0.102: v1(72.49,84.12) 71.76,84.12 70.82,85.05 70.33,85.05 R311.2 69.83,86.5 C138.1 69.59,88.76 Y2.1 ; v1(73.33,77.48) 73.7,77.12 U7.M22
N16512880: length 1.6
  BOTTOM w0.108: U8.4 100.71,67.52 R182.1
N18086472: length 3
  TOP w0.108: LED2.2 6.28,3.93 7.07,3.93 R266.1
N18086480: length 2.7
  TOP w0.108: R267.1 5.73,1.5 LED2.1
N18134434: length 16.6
  TOP w0.108: R25.2 15.43,24.54 15.06,24.91 15.06,27.57 16.46,28.97 17.65,28.97 v1(18.58,29.9) 18.87,30.18 18.87,31.85 18.04,32.68 D7.1 18.04,35.15 18.14,35.25 19.68,35.25 19.81,35.12 D8.1
N18218785:
  vias: v1(50.72,92.78)
N18853812: length 3.6
  TOP w0.203: C36.1 R67.2 v1(3.7,19.4) 3.77,19.33 4.68,19.33 4.81,19.2 U4.27
N19249672: length 4
  TOP w0.508: C316.2 R496.2 110.75,52.05 v1(110.46,51.76)
  BOTTOM w0.203: U19.8 110.12,52.09 v1(110.46,51.76) 110.62,51.92 U19.7
N19667233: length 3.8
  BOTTOM w0.254: U13.7 137.78,73.57 138.3,73.04 138.3,72.96 v1(138.41,72.86) 138.67,72.86 139.12,72.41 R403.1 R399.1
N19667243: length 2.5
  BOTTOM w0.254: R396.2 138.99,74.13 138.66,74.46 v1(138.63,74.46) 138.04,74.46 137.79,74.22 U13.6
N19667397: length 3.3
  BOTTOM w0.108: R1201.2 128.15,69.44 R415.2 129.56,69.44 v1(129.8,69.21) 130.23,69.21 130.41,69.02 U13.15
N19667450: length 5.4
  BOTTOM w0.108: TP23.1 141.63,78.91 140.97,78.25 139.9,78.25 139.28,77.62 138.29,77.62 138.13,77.47 U13.1
N19667455: length 10.3
  BOTTOM w0.108: U13.2 137.85,76.82 138.44,77.41 139.37,77.41 139.92,77.96 140.72,77.96 141.13,77.55 141.79,77.55 142.82,78.58 146.4,78.58 TP27.1
N19667489: length 4.4
  TOP w0.108: v1(138.58,72.27) 139.3,72.27 R1012.2 v1(140.22,73.18) R408.2
  BOTTOM w0.108: U13.9 v1(138.58,72.27)
N19667717: length 2.3
  BOTTOM w0.108: U13.28 130.41,77.47 130.16,77.72 130.16,78.31 TP25.1
N19837103: length 8.8
  TOP w0.108: R493.1 45.2,25.36 Q41.3 39.32,25.36 v1(38.99,25.03) 38.36,24.4 Q42.2
N20065575: length 18.6
  BOTTOM w0.064: U20.K5 118,77.16 118,79.24
  BOTTOM w0.108: 118,79.24 117.53,79.71 117.53,80.08 116.78,80.83 112,80.83 108.43,77.25 D22.2 105.96,77.25 105.76,77.05 105.76,76.08 R490.2
N20159060: length 3.3
  BOTTOM w0.108: R73.2 R71.1 R72.1 46.86,29.17 Q5.2
N20159096: length 7.3
  TOP w0.108: MR1.1 155.05,104.13 R17.1 154.09,106.13 v1(154.89,106.13) C17.1 154.89,107.63 155.29,108.03 D5.1
N20218729: length 4.4
  BOTTOM w0.108: U11.5 129.06,81.63 129.19,81.76 129.19,82.48 128.88,82.79 127.69,82.79 v1(127.48,83) 127.84,83.35 R401.2
N20310085: length 4.5
  TOP w0.254: 13.21,31.46 13.95,31.46 v1(14.2,31.71) C76.2 14.98,31.67 15.76,30.89 R125.1 R124.2
N20824488: length 6.4
  BOTTOM w0.108: U17.5 96.44,84.17 R232.1 95.62,84.99 95.62,85.8 v1(95.4,86.02) 95.24,85.86 93.7,85.86 93.32,85.48 93.32,84.83 R220.1
N21039756: length 5.5
  TOP w0.108: R128.1 147.07,101.67 147.47,101.26 v1(147.85,101.26) 148.27,101.26 R376.2 C75.2 150.9,100.96 Q27.2
N21041656: length 3.8
  TOP w0.203: U21.7 v1(119,24.48) 119.03,24.48 119.39,24.84 R514.2
N21053283: length 6.7
  TOP w0.108: Q25.3 145.83,80.23 145.66,80.05 144.6,80.05 144.15,79.6 144.15,78.12 v1(143.71,77.68) R360.2 R351.2
N21085249: length 3.4
  BOTTOM w0.108: PR135.2 25,86.73 26.85,86.73 26.93,86.81 PR136.1
N21086309: length 12.2
  TOP w0.381: PC10.2 16.67,90.88 PR1.2 PR5.1 17.67,92.07 PQ1.6 18.89,91.67 19.33,91.23 21.41,91.23 22.56,92.37 v1(22.56,92.9) 22.56,93.41 v1(22.35,93.61)
  BOTTOM w0.381: PQ15.4 21.04,94.93 v1(22.35,93.61)
N21086343: length 36.7
  TOP w0.508: PQ10.4 PR229.2 86.17,24.94 83.19,27.93 61.21,27.93 v1(61.11,27.84) v1(57.22,27.84)
  BOTTOM w0.508: PR230.1 58.05,25.48 57.39,26.15 57.39,27.67 v1(57.22,27.84)
N21086349: length 3.1
  TOP w0.108: PQ1.3 20.89,88.7 20.68,88.48 v1(20.5,88.48) 20.07,88.48 19.89,88.66 PQ1.2
N21086359: length 105.7
  TOP w0.254: PQ1.5 19.89,92.9 19.62,93.17 PR10.2 19.77,93.61 20.19,93.61 v1(20.47,93.34) 21.34,93.34 22.15,94.15 22.61,94.15 23.27,93.49 23.27,92.48 21.77,90.98 21.77,88.48 v1(22.71,87.54)
  IN1 w0.254: v1(55.31,27.84) 55.18,27.72 41.87,27.72 39.34,30.25 37.18,30.25 31.96,35.47 31.96,44.34 33.47,45.84 33.47,46.7 35.15,48.39 35.15,52.44 34.07,53.52 31.37,53.52 31.14,53.75 29.48,53.75 29.1,54.13 29.1,54.69 27.8,55.98 26.05,55.98 25.46,56.57 25.46,63.17 26.89,64.6 26.89,65.56 27.79,66.46 27.79,72.41 25.43,74.77 25.43,81.54 24.65,82.32 24.65,85.97 23.07,87.54 v1(22.71,87.54)
  BOTTOM w0.254: PQ37.2 55.73,26.76 55.31,27.19 v1(55.31,27.84)
N21086370: length 11.2
  BOTTOM w0.152: PR96.1 86.8,27.87 84.5,27.87 84.2,28.17 84.2,29.91 84.05,30.06 81.15,30.06 80.77,29.68 80.77,27.75 80.88,27.64 81.46,27.64 PR113.1
N21086453: length 3.7
  TOP w0.108: PC81.1 v1(91.44,27.47)
  TOP w0.635: PC81.1 91.44,25.89 91.16,25.61 90.33,25.61 PR86.2
N21086471: length 5.9
  TOP w0.108: PR225.1 v1(74.04,21.58)
  BOTTOM w0.108: v1(74.04,21.58) 73.3,22.32 PJ2.3
N21086542: length 6.5
  TOP w0.108: PR226.1 69.42,21.38 v1(69.62,21.58)
  BOTTOM w0.108: PJ2.4 71.31,23.27 v1(69.62,21.58)
N21086652: length 152.4
  TOP w0.254: PR122.1 103.36,21.69 103.55,21.88 PR127.2 104.2,22.51 v1(104.83,23.14)
  IN1 w0.254: v1(104.83,23.14) 104.83,23.81 104.47,24.17 104.47,24.74 104.03,25.17 104.03,25.18 103.79,25.43 103.79,26.81 102.11,28.49 94.95,28.49 94.39,29.05 79.19,29.05 78.21,28.07 75.78,28.07 75.02,27.32 41.71,27.32 39.17,29.85 37.01,29.85 31.56,35.3 31.56,44.5 33.07,46.01 33.07,46.86 34.76,48.55 34.76,52.28 33.91,53.13 31.21,53.13 30.98,53.36 29.31,53.36 28.7,53.97 28.7,54.52 27.64,55.59 25.89,55.59 25.07,56.4 25.07,63.34 26.5,64.77 26.5,65.73 27.39,66.62 27.39,72.25 25.03,74.61 25.03,81.38 24.26,82.15 24.26,85.8 23.1,86.96 22.47,86.96 22.1,86.96 v1(22.07,86.93)
  BOTTOM w0.254: v1(22.07,86.93) 21.69,87.32 21.18,87.32 19.94,86.07 PD3.1
N21086663: length 26
  TOP w0.508: PR127.1 v1(105.4,22.72) ; PR126.1 v1(86.64,26.24)
  IN1 w0.508: v1(105.4,22.72) 105.08,22.41 104.31,22.41 103.37,23.35 103.37,24.1 103.51,24.24 103.51,24.97 103.25,25.22 103.25,26.48 v1(102.19,27.55)
  IN2 w0.508: v1(102.19,27.55) 99.62,27.55 98.88,26.81 97.16,26.81 96.52,27.45 87.85,27.45 v1(86.64,26.24)
N21086667: length 3.7
  TOP w0.254: PR117.1 102.74,25.36 102.08,24.7 102.08,23.61 101.45,22.98 PU8.8
N21086672: length 3.9
  TOP w0.254: PR114.1 102.36,25.75 102.36,25.62 101.7,24.96 101.7,23.86 101.31,23.48 PU8.9
N21086756: length 2.4
  TOP w0.152: PU8.13 99.06,25.42 98.81,25.67 98.78,25.68 v1(98.45,25.68) 98.45,26.4 PR101.2
N21086758: length 2.6
  TOP w0.152: PR100.2 99.75,26.69 v1(99.75,25.75) 99.75,25.44 99.56,25.26 PU8.12
N21086804: length 1.7
  BOTTOM w0.508: PQ37.3 58.42,26.64 PR230.2
N21086812: length 7
  BOTTOM w0.254: PQ11.3 102.36,28.62 v1(102.36,29.68) 101.3,29.68 101.06,29.45 101.06,28.89 100.65,28.48 99.44,28.48 99.32,28.61 99.32,29.81 99.05,30.07 PR105.1
N21086823: length 19.2
  TOP w0.254: v1(97.72,27.55) 97.54,27.36 PR125.1 96.19,27.95 96.32,28.08 96.93,28.08 97.1,28.26 PQ36.5 PQ36.2 ; v1(101.96,21.03) 101.73,21.26 100.92,21.26 100.41,20.74 100.22,20.74 100.06,20.9 PU8.5
  IN1 w0.254: v1(101.96,21.03) 102.19,21.26 102.19,25.32 102.52,25.64 102.52,25.9 100.86,27.55 v1(97.72,27.55)
N21086841: length 3.8
  TOP w0.254: PQ36.6 97.75,29.67 97.97,29.89 98.46,29.89 v1(98.67,30.1) PR221.1 PR222.2
N21086931: length 6.3
  TOP w0.108: PR227.1 v1(68.35,21.58)
  BOTTOM w0.108: v1(68.35,21.58) 69.32,22.55 PJ2.5
N21092228:
  vias: v1(111.3,98.87)
N21092230: length 20.7
  IN2 w0.508: v1(101.73,96.74) 101.73,94.16 102.87,93.02 111.97,93.02 113.51,94.57 v1(113.51,97.65)
  BOTTOM w0.203: v1(113.51,97.65) 113.23,97.93 113.23,98.72 113.37,98.85 PU1.19
N21092239: length 2.1
  TOP w0.254: v1(116.89,100.57) 117.22,100.9 PR6.2 PR2.2
N21092313: length 18
  IN2 w0.508: v1(112.94,105.07) 112.58,105.07 111.67,105.98 111.67,109.74 110.79,110.62 105.18,110.62 104.7,110.15 104.7,109.62 104.36,109.28 102.66,109.28 v1(102,108.62)
  BOTTOM w0.203: PU1.3 113.37,104.52 113.31,104.58 113.31,104.7 v1(112.94,105.07)
  vias: v1(101.73,111.17)
N21092367: length 2
  BOTTOM w0.203: PC11.1 114.84,98.76 114.57,99.04 PU1.16
N21092424:
  vias: v1(112.14,97.48)
N21092523: length 7.3
  BOTTOM w0.203: 110.72,102.14 PU1.26
  BOTTOM w0.254: PR7.1 105.33,102.19 105.72,102.58 106.82,102.58 C702.1 107.92,102.46 110.4,102.46 110.72,102.14
N21092531: length 7.8
  BOTTOM w0.203: 110.55,101.74 PU1.25
  BOTTOM w0.254: PR3.2 105.13,101.46 109.03,101.46 PR8.2 109.66,102.09 110.2,102.09 110.55,101.74
N21092542: length 6
  TOP w0.254: PR133.2 v1(108.24,100.88) R317.2
  BOTTOM w0.203: PU1.24 110.7,101.34 110.44,101.09
  BOTTOM w0.254: PR4.2 v1(108.24,100.88) 108.29,100.93 110.29,100.93 110.44,101.09
N21092547: length 3.6
  TOP w0.254: PR232.2 PR134.2 PR233.2 113.47,105.18 v1(113.7,104.95)
  BOTTOM w0.203: PU1.4 113.77,104.88 v1(113.7,104.95)
N21094638: length 2.2
  BOTTOM w0.254: PC85.1 36.41,46.41 36.73,46.73 v1(36.73,46.88) 36.73,47.11 36.48,47.36 PR90.1
N21094642: length 3.2
  BOTTOM w0.203: 33.78,48.91 33.78,49.22 33.69,49.3 PU7.5
  BOTTOM w0.254: 33.78,48.91 33.97,48.72 34.03,48.72 34.15,48.61 34.24,48.61 v1(34.37,48.48) 34.54,48.31 PC87.2 PR90.2
N21094874: length 2.8
  BOTTOM w0.508: PR132.1 30.3,45.41 31.66,44.06
  vias: v1(30.43,44.19)
N21094973:
  vias: v1(24.9,45.84)
N21097743: length 35
  IN2 w0.254: v1(39.55,82.59) 39.12,82.16 39.12,79.29 38.84,79.01 38.36,79.01 38.15,79.21 36.96,79.21 34.25,76.51 34.25,71.65 36.33,69.57 37.82,69.57 38.34,69.05 38.34,68.3 39.32,67.33 41.63,67.33 43.92,65.04 44.48,65.04 44.83,65.4 v1(44.83,65.55)
  BOTTOM w0.254: PR25.2 44.83,65.82 v1(44.83,65.55) 45.14,65.24 PC37.1 45.71,65.07 46.99,63.8 PC24.1 48.57,63.8 PR20.2 ; PR19.2 39.15,82.19 v1(39.55,82.59)
N21097745: length 5.6
  BOTTOM w0.203: PU4.29 43.48,65.32 43.92,64.89
  BOTTOM w0.254: PR153.2 46.14,62.07 PR155.2 45.63,62.8 45.09,63.34 45.09,63.72 v1(44.62,64.19) 43.92,64.89
N21097753: length 41.1
  TOP w0.254: v1(41.28,60.1) 41.74,60.56 PR33.2 44.17,58.3 PC48.1 43.62,57.39 42.08,57.39 PC129.1 ; v1(43.79,83.73) 43.71,83.66 PR147.1 PR148.2
  IN1 w0.254: v1(43.79,83.73) 43.79,83.89 44.27,84.37 45.67,84.37 48.16,81.88 48.16,77.31 48.44,77.03 48.44,71.87 48.15,71.58 48.15,68.7 48.34,68.51 48.34,67.17 47.39,66.23 47.39,65.97 45.07,63.66 45.07,62.89 44.36,62.17 43.32,62.17 43.15,62.01 42.56,62.01 42.27,61.71 42.27,61.09 v1(41.28,60.1)
  BOTTOM w0.254: v1(41.28,60.1) PR29.2
N21097757: length 29.4
  TOP w0.254: v1(45.97,66.59) 45.64,66.26 PR21.2
  IN2 w0.254: v1(45.97,66.59) 45.97,65.83 44.77,64.63 43.77,64.63 41.47,66.93 39.16,66.93 37.95,68.14 37.95,68.89 37.66,69.18 36.17,69.18 33.86,71.49 33.86,76.67 36.79,79.61 38.55,79.61 v1(38.58,79.57)
  BOTTOM w0.254: PR22.2 38.22,79.93 v1(38.58,79.57)
N21097815: length 2.1
  TOP w0.254: PR51.2 35.21,68.52 v1(35.33,68.39)
  BOTTOM w0.254: PR37.1 v1(35.33,68.39) PC56.2
N21097880: length 3.8
  TOP w0.254: PC48.2 43.39,58.1 42.42,59.07 41.48,59.07 v1(41.17,59.38)
  BOTTOM w0.254: v1(41.17,59.38) 41.44,59.11 PR32.2
N21097916: length 1.9
  BOTTOM w0.254: PC43.2 42.67,60.34 43.11,60.34 43.55,59.9 PR30.1
N21098033: length 27.8
  IN2 w0.14: v1(32.18,66.77) 29.62,69.33 29.62,71.92 28.53,73.02 28.53,77.18 30.23,78.88 v1(30.23,78.98)
  BOTTOM w0.108: v1(32.18,66.77) 32.52,67.11 PR50.1 ; v1(30.23,78.98) 30.23,78.99 35.78,78.99 v1(36.28,79.48) 38.52,81.73 38.52,82.71 39.08,83.27 PR45.2 PR177.1
N21098047: length 1.7
  BOTTOM w0.203: PU4.10 37.15,64.52 37.11,64.48 PR49.1
N21098063: length 2.1
  BOTTOM w0.203: 40.89,62.58 PU4.4
  BOTTOM w0.254: 40.89,62.58 41.15,62.32 41.15,61.6 PR29.1
N21098069: length 1.7
  TOP w0.254: PR39.1 38.63,60.37 38.63,59.99 v1(38.43,59.78) 38.35,59.7 PR46.1
N21098076: length 1.8
  BOTTOM w0.254: PR176.2 38.51,60.48 v1(38.51,59.96) 38.51,59.93 37.98,59.41 PR181.1
N21098081: length 1.8
  BOTTOM w0.254: PR47.2 37,59.44 37.72,60.16 PR40.1
N21098093: length 3.8
  TOP w0.254: PR180.2 37.08,58.82 v1(36.35,59.55) 36.35,60.26 36.81,60.72 v1(36.91,60.72)
  BOTTOM w0.254: PR175.2 36.64,60.72 v1(36.91,60.72)
N21098098: length 1.1
  TOP w0.254: PR48.2 37.64,62.19 37.65,62.21 PR41.1
N21098107: length 1.3
  BOTTOM w0.254: PR174.2 36.81,62.66 PR179.1
N21098112: length 13.3
  TOP w0.254: PR54.1 40.76,63.37 40.36,63.77 v1(40.21,63.77) 39.77,63.77 PR55.2 38.51,62.93 37.64,63.8 37.06,63.8 36.35,63.08 36.35,62.37 36.86,61.87 PR48.1 37.69,60.7 PR46.2 37.28,60.06 v1(36.93,60.06)
  BOTTOM w0.254: v1(36.93,60.06) 35.92,60.06 35.61,59.76 PC60.1 36.39,58.66 PR47.1
N21098137: length 3.2
  TOP w0.108: v1(43.04,68.51) 42.21,68.51 PR27.2
  BOTTOM w0.108: v1(43.04,68.51) 43.05,68.51 42.46,68.51 42.09,68.14 PU4.24
N21098141: length 3.7
  TOP w0.108: PR27.1 v1(39.78,67.96) 39.45,67.96 v1(38.86,68.55)
  BOTTOM w0.108: v1(38.86,68.55) 39.12,68.55 39.37,68.29 39.52,68.29 39.69,68.12 PU4.18
N21098147: length 1.3
  BOTTOM w0.254: PR158.1 46.14,61.05 PR159.1
N21098149: length 5
  TOP w0.254: PC34.1 44.59,63.31 v1(44.04,63.31)
  BOTTOM w0.203: PU4.31 43.33,64.52 43.5,64.35 43.5,63.76 43.94,63.31 v1(44.04,63.31)
  BOTTOM w0.254: v1(44.04,63.31) 44.04,63.08 44.35,62.78 44.35,62.06 PR158.2
N21098151: length 1.3
  BOTTOM w0.254: PR160.1 45.6,59.29 PR161.1
N21098153: length 3.8
  BOTTOM w0.254: PR160.2 v1(46.36,58.51) 46.43,58.51 46.74,58.82 PR152.1 47.26,59.79 47.26,60.16 47.51,60.41 PR159.2
N21098161: length 1.3
  BOTTOM w0.254: PR152.2 46.1,60.04 PR151.1
N21098163: length 32.1
  IN1 w0.14: v1(42.98,63.59) 42.98,64.03 43.57,64.63 44.68,64.63 46.43,66.38 46.43,71.92 46.91,72.41 v1(46.97,72.41)
  IN2 w0.14: v1(46.97,72.41) 46.97,72.48 47.04,72.55 47.04,81.21 45.01,83.24 45.01,84.04 44.71,84.34 44.04,84.34 43.58,84.81 v1(41.33,84.81)
  BOTTOM w0.108: v1(42.98,63.59) 44.04,62.53 44.04,61.81 44.4,61.46 44.4,60.97 PR151.2 ; v1(41.33,84.81) PR26.1
N21098205: length 2
  TOP w0.254: PR165.1 44.05,62.35 v1(44.33,62.07) 44.59,61.81 PR163.1
N21098274: length 8.4
  BOTTOM w0.254: PR19.1 39.36,81.02 39.93,81.02 40.44,80.51 40.44,79.3 41.46,78.27 43.16,78.27 43.44,78.55 PL4.4
N21098278: length 8.4
  BOTTOM w0.254: PR22.1 39.28,80.54 39.75,80.54 40.01,80.28 40.01,79.09 41.33,77.77 43.03,77.77 43.44,77.36 PL4.3
N21098343: length 1.9
  BOTTOM w0.508: PC41.2 42.27,70.83 41.29,71.81 PR31.1
N21100012: length 1
  BOTTOM w0.254: PR61.2 118.63,57.6 PR63.1
N21100035: length 9.4
  TOP w0.254: v1(116.97,53.29) 117.51,52.75 PC70.1
  IN1 w0.254: v1(116.97,53.29) 116.9,53.37 116.9,54.81 117.46,55.37 v1(117.46,55.4)
  BOTTOM w0.254: PR74.2 PR72.2 PC71.1 117.08,53.18 v1(116.97,53.29) ; PR60.2 117.45,57.82 117.09,57.46 117.09,55.77 v1(117.46,55.4)
N21100086: length 29.4
  TOP w0.254: PR213.2 111.79,62.43 111.89,62.43 PR216.1 112.4,61.28 v1(111.99,60.87) ; v1(121.48,47.22) PR214.2 PR93.2 PC162.1
  IN1 w0.254: v1(121.48,47.22) 121.05,46.8 115.62,46.8 114.19,48.24 114.19,50.93 113.66,51.46 113.66,54.11 114.94,55.39 114.94,57.93 v1(111.99,60.87)
  BOTTOM w0.254: PC89.1 121.48,47 v1(121.48,47.22)
N21100137: length 1
  BOTTOM w0.254: PC89.2 PR106.2
N21100164: length 1
  BOTTOM w0.254: PR98.1 120.52,47.83 PC83.2
N21100271: length 4.9
  BOTTOM w0.254: PR199.1 125.41,55.4 124.89,55.92 124.89,55.92 124.44,56.38 v1(124.44,56.56) PR53.2 PR185.1
N21100284: length 2.7
  TOP w0.203: PU6.10 125.57,51.67 125.88,51.37 v1(126.31,51.37)
  BOTTOM w0.254: PR82.1 126.98,51.77 126.58,51.37 v1(126.31,51.37)
N21100302: length 2.1
  TOP w0.203: PU6.4 122.74,49.87 122.43,49.56 PR93.1
N21100314: length 1
  TOP w0.254: PR103.2 PR99.1
N21100326: length 1
  TOP w0.254: PR95.1 PR107.2
N21100328: length 20.2
  TOP w0.254: PR89.2 117.1,50.3 v1(116.58,49.77)
  IN1 w0.254: v1(130.39,52.25) 129.1,52.25 128.58,52.77 126.26,52.77 125.74,52.24 125.74,51.06 125.63,50.95 125.63,50.34 125.27,49.97 125.27,48.95 124.61,48.29 117.15,48.29 116.58,48.86 v1(116.58,49.77)
  BOTTOM w0.254: PR88.1 v1(130.39,52.25)
N21100340: length 18.9
  TOP w0.254: v1(115.69,50.97) 115.69,50.97 116.22,50.45 PR89.1 115.88,50 v1(115.88,49.09) 116.49,48.48 116.49,45.96 117.01,45.43 118.7,45.43 PC160.1 119.88,45.92 v1(119.91,45.89) 120.55,45.25 123.91,45.25 124.73,46.07 PR107.1 PR103.1
  BOTTOM w0.254: PR207.1 119.59,47.81 119.59,47.05 119.91,46.73 v1(119.91,45.89) ; PR87.2 116.12,51.4 v1(115.69,50.97)
N21100369: length 2.3
  TOP w0.203: v1(121.03,55.43) 121.25,55.43 121.54,55.14 PU6.24
  BOTTOM w0.254: v1(121.03,55.43) 121.34,55.12 PR64.2
N21100377: length 3
  TOP w0.254: PR84.1 v1(117.29,47.4) 117.74,47.4 117.8,47.34 v1(118.16,47.34) 118.16,47.34 118.62,47.8 PR85.2
  BOTTOM w0.254: PR94.2 117.66,47.78 118.09,47.34 v1(118.16,47.34)
N21100379: length 1.3
  BOTTOM w0.254: PR94.1 117.85,48.61 PR81.1
N21100381: length 4.7
  TOP w0.203: PC76.1 118.88,49.5 119.2,49.83 v1(119.79,49.83) 119.79,49.88 120.14,50.23 120.14,51.51 120.3,51.67 PU6.31
  BOTTOM w0.254: PC76.1 119.21,49.83 v1(119.79,49.83)
N21100383: length 2.2
  TOP w0.254: PR85.1 v1(117.78,48.61) 117.52,48.87 v1(117.52,49.21)
  BOTTOM w0.254: PR78.1 117.82,49.21 v1(117.52,49.21)
N21100387: length 2.5
  TOP w0.203: PU6.18 123.94,55.4 v1(124.25,55.71)
  BOTTOM w0.254: PR64.1 123.65,55.12 v1(124.25,55.71)
N21100399: length 18.9
  TOP w0.254: v1(119.1,47.34) 118.87,47.34 PR83.2
  IN1 w0.254: v1(119.1,47.34) 118.55,47.89 116.49,47.89 114.69,49.69 114.69,51.92 115.32,52.54 115.32,55.04 117.19,56.92 119.37,56.92 v1(119.46,57.01)
  BOTTOM w0.254: PR28.1 119.35,58.12 119.35,57.12 v1(119.46,57.01)
N21100401: length 1
  TOP w0.254: PR84.2 PR83.1
N21100433: length 4
  TOP w0.203: PU6.29 119.95,52.47 v1(119.55,52.07) 119.23,51.75 119.11,51.75 PR196.2
  BOTTOM w0.254: v1(119.55,52.07) 119.71,51.9 v1(119.71,51.37) 119.08,51.37 PR75.2
N21100449: length 1.1
  TOP w0.254: PR212.1 120.66,47.69 120.66,46.96 PR215.1
N21100533: length 7.6
  BOTTOM w0.254: PL5.3 121.87,62.7 121.39,62.22 121.39,61.43 119.48,59.52 118.69,59.52 118.6,59.43 118.6,58.84 PR61.1
N21100556: length 7.9
  BOTTOM w0.254: PR60.1 118.24,59 118.24,59.58 118.54,59.88 119.33,59.88 120.93,61.48 120.93,62.22 120.45,62.7 PL5.4
N21100764: length 2.1
  TOP w0.254: PC153.2 v1(128.37,56.35) PR193.1
  BOTTOM w0.254: PR191.2 v1(128.37,56.35)
N21100901: length 2
  TOP w0.508: PR56.1 121.1,58.28 v1(120.13,58.28) PC68.2
N21102302: length 176.5
  IN1 w0.127: v1(121.77,41.67) 121.21,41.11 119.51,41.11 118.47,40.07 v1(117.8,40.07) 117.8,40.16 117.22,40.73 114.18,40.73 111.71,38.27 107.44,38.27 104.27,35.1 98.77,35.1 98.33,35.54 95.98,35.54 95.62,35.18 93.24,35.18 92.34,34.29 88.59,34.29 88.28,34.59 78.38,34.59 76.28,32.5 42.55,32.5 40.94,34.11 40.67,34.11 40.66,34.11 40.44,34.11 40.44,34.11 38.78,34.11 37.19,35.69 37.19,38.81 37.59,39.21 37.59,39.92 v1(37.09,40.43) ; v1(45.09,88.74) 45.03,88.8 42.85,88.8 41.12,90.53 37.32,90.53 37.1,90.53 36.44,89.86 36.44,87.74 38.25,85.93 38.25,81.51 35.72,78.98 35.08,78.98 32.26,76.16 32.26,71.9 v1(32.28,71.87)
  IN2 w0.127: v1(32.28,71.87) 32.94,71.87 34.55,70.27 34.55,68.01 34.85,67.71 35.82,67.71 36.3,67.22 36.3,60.14 35.99,59.83 35.99,57.85 36.98,56.86 36.98,53.18 36.68,52.87 36.68,45.89 36.04,45.25 36.04,41.47 v1(37.09,40.43)
  BOTTOM w0.127: v1(45.09,88.74) 45.34,88.74 45.59,88.99 46.18,88.99 47.2,87.98 52.84,87.98 PR16.1 ; v1(121.77,41.67) 121.77,42.71 PR15.2 ; v1(117.8,40.07) 116.33,38.61 PU2.2
N21102304: length 5.8
  BOTTOM w0.508: PR11.1 PR12.1 PC20.2 118.61,42.48 118.42,42.28 118.42,41.82 118.21,41.61 117.81,41.61 117.6,41.82 PU2.8
N21102308: length 8.4
  TOP w0.508: PQ21.1 116.64,38.95 116.23,39.37 PR17.1 115.44,38.4 v1(115.97,37.87) 116.35,37.49 116.35,34.95 115.78,34.38 PD1.1
N21102320: length 2.9
  TOP w0.508: PQ21.3 119.84,39.51 v1(120.42,39.51)
  BOTTOM w0.508: v1(120.42,39.51) 120.42,40.57 120.36,40.63 PR12.2
N21102324: length 6.5
  TOP w0.508: PQ21.2 116.62,40.99 116.2,40.57 PR17.2 115.32,40.57 114.66,39.91 114.66,39.16 v1(114.25,38.75) 114.66,38.34 PQ24.3
N21102361: length 8.4
  TOP w0.508: v1(119.93,38.89) 118.29,37.25 PQ16.2
  BOTTOM w0.508: PU2.1 117.6,37.91 117.76,38.06 118.06,38.06 118.33,37.8 118.33,37.7 118.91,37.11 PC117.2 PR11.2 119.52,38.48 v1(119.93,38.89)
N21102373: length 173.7
  IN1 w0.127: v1(45.93,88.48) 44.66,87.21 43.31,87.21 43.01,87.51 43.01,88.26 41.01,90.26 37.21,90.26 36.7,89.75 36.7,87.85 38.51,86.04 38.51,81.62 38.51,81.62 38.51,81.4 35.83,78.72 35.19,78.72 32.53,76.05 32.53,72.37 32.77,72.13 32.77,71.52 v1(32.44,71.19) ; v1(37.09,39.69) 36.93,39.53 36.93,35.58 38.67,33.84 40.83,33.84 42.44,32.23 76.39,32.23 78.47,34.31 88.16,34.31 88.47,34 92.43,34 93.35,34.92 95.73,34.92 96.09,35.27 98.22,35.27 98.66,34.83 104.38,34.83 107.55,38 111.82,38 114.26,40.44 117.01,40.44 117.34,40.11 117.34,39.88 117.63,39.59 118.37,39.59 119.62,40.85 121.4,40.85 121.59,41.04 v1(121.95,41.04)
  IN2 w0.127: v1(37.09,39.69) 35.76,41.01 35.76,45.37 36.4,46 36.4,52.99 36.7,53.29 36.7,56.75 35.71,57.74 35.71,59.95 36.02,60.25 36.02,67.11 35.7,67.43 34.73,67.43 34.27,67.9 34.27,70.16 33.24,71.19 v1(32.44,71.19)
  BOTTOM w0.127: PR16.2 52.3,87.74 47.1,87.74 46.36,88.48 v1(45.93,88.48) ; PQ3.3 122.5,40.49 v1(121.95,41.04)
N21102766: length 3.8
  TOP w0.508: Q79.3 103.97,89.46 v1(103.84,89.6) PR238.2 102.51,89.6 102.51,88.21 PR138.2
N21102772:
  vias: v1(86.74,103.22)
N21102817: length 5.4
  TOP w0.508: PR139.2 109.34,85.99 v1(109.35,85.99) 109.35,86.43 108.69,87.08 PQ20.3
N21108515: length 8.7
  TOP w0.508: Q45.1 v1(48.17,25.55)
  BOTTOM w0.508: R501.2 R507.2 51.17,25.12 51.13,25.08 R510.1 50.42,25.43 49.79,26.06 C318.2 C317.1 48.87,26.25 v1(48.17,25.55)
N21108595: length 8.9
  TOP w0.108: v1(51.22,28.25) v1(51.22,27.22) 51.22,23.88 50.86,23.52 Q45.2
  BOTTOM w0.108: v1(51.22,28.25) 51.01,28.25 C318.1 50.15,26.66 50.26,26.66 R497.2
N21125286: length 2.5
  BOTTOM w0.108: R427.1 99.07,85.75 98.73,85.41 v1(98.73,85.18) 98.73,84.95 98.94,84.74 U16.5
N21132627: length 4.7
  TOP w0.203: L8.2 10.98,13.16 9.99,14.16 U4.46 ; 7.53,13.39 7.99,13.84 U4.41
  TOP w0.381: 7.53,13.39 7.53,12.27
  vias: v1(7.82,11.93)
N21260714: length 3.1
  TOP w0.508: R407.2 R400.1 v1(142.5,98.62) 142.5,98.89 Q31.2
N21264338: length 1.9
  TOP w0.102: R74.2 12.49,16.8 U4.4
N21358530: length 22.3
  TOP w0.508: PQ31.2 111.83,90.09 v1(111.61,90.31) 111.61,90.55 112.23,91.18 112.47,91.18 PR190.2 113.1,91.95 111.9,93.15 PR189.1 111.76,93.64 112.68,94.55 115.7,94.55 116.24,94.01 117.18,94.01 118.1,93.09 PQ27.2 118.1,86.98 PQ30.3
N21358603: length 3
  TOP w0.508: PQ27.3 116.41,88.08 116.08,87.75 v1(116.08,87.29) 116.08,86.93 116.79,86.21 PR183.2
N21362550: length 12.9
  IN2 w0.14: v1(78.66,75.34) 79.09,74.91 83.59,74.91 84.89,76.22 88.35,76.22 v1(88.45,76.12)
  BOTTOM w0.102: v1(78.66,75.34) U7.T13
  BOTTOM w0.108: R494.1 v1(89.26,76.68) 89.01,76.68 v1(88.45,76.12)
N21395083: length 2.1
  TOP w0.254: v1(78.66,76.33) v1(78.66,77) 78.52,77.15 R100.1
  BOTTOM w0.305: v1(78.66,76.33) 78.66,76.19 U7.P13
N21417954: length 5
  BOTTOM w0.102: U7.B53 58.59,82.53 58.75,82.69 58.75,83.07 57.94,83.89 57.94,83.94
  BOTTOM w0.108: R45.2 57.33,85.82 57.94,85.21 57.94,83.94
N21417957: length 5.5
  BOTTOM w0.102: U7.A52 59.02,83.1 58.18,83.94
  BOTTOM w0.108: R44.2 56.91,86.61 57.46,86.06 57.46,86 58.15,85.3 58.15,83.96 58.18,83.94
N21604905:
  vias: v1(144.5,106.95)
N21665898: length 11.4
  BOTTOM w0.108: R294.1 42.57,92.51 R278.1 42.57,91.34 R280.1 42.55,91.3 42.44,91.2 39.98,91.2 39.78,91 39.78,89.83 39.29,89.35 38.23,89.35 37.47,90.11 v1(36.81,90.11) R290.1
N21685145: length 1.9
  BOTTOM w0.203: PU5.11 133.76,108.51
  BOTTOM w0.254: 133.76,108.51 133.76,108.86 v1(133.75,108.87) PC69.2
N22167393: length 6.7
  TOP w0.254: R257.2 C126.1 R259.2 150.12,41.54 149.61,41.04 v1(149.61,40.99) Q13.2 149.61,39 149.48,38.88 149.12,38.88 148.96,39.04 Q13.3
N22167500: length 4.9
  TOP w0.254: Q13.6 150.26,38.36 150.44,38.54 150.8,38.54 151.13,38.2 R1038.2
  TOP w0.508: R1037.2 v1(151.77,39.46) R1038.2
N22770206: length 4.7
  BOTTOM w0.108: R62.2 59.66,87.08 59.69,87.11 59.69,87.85 59.37,88.17 58.77,88.17 58.53,88.4 C33.2 58.01,88.71 58.01,88.71 v1(57.76,88.71) R46.1
N23050514: length 6.9
  TOP w0.254: CN9.10 154.71,59.92 153.12,59.92 v1(152.77,59.56) R1020.1 R1021.1
N23242231: length 9.7
  TOP w0.203: 7.59,22.38 7.99,21.99 U4.20
  TOP w0.254: R1014.2 10.31,23.87 10.21,23.97 8.66,23.97 v1(8.64,23.99) 8.31,24.32 6.81,24.32 5.97,23.49 5.97,22.59 6.18,22.38 7.59,22.38
N23537790: length 3.2
  TOP w0.508: PR146.2 PR145.1 143.46,94.3 PD6.2
N23537831: length 6.1
  TOP w0.508: PR18.2 138.52,94.93 v1(138.05,94.45) 137.47,93.87 PC32.2 PC132.2 PC134.2
N23562987: length 7.3
  TOP w0.108: R340.1 74.73,82.63 v1(74.73,82.71)
  IN2 w0.102: v1(76.24,79.61) 76.1,79.75 74.12,79.75 73.86,80 73.86,81.09 73.88,81.11
  IN2 w0.14: 73.88,81.11 73.88,81.18 74.73,82.03 v1(74.73,82.71)
  BOTTOM w0.102: v1(76.24,79.61) U7.G18
N23981964: length 5.3
  BOTTOM w0.102: 86.36,83.41 R50.1 ; U7.A3 83.35,82.77 83.99,83.41 86.31,83.41
  BOTTOM w0.108: 86.31,83.41 86.36,83.41
N24050420: length 2.6
  TOP w0.254: Q65.2 144.82,83.88 144.28,84.41 R671.1
N24425848: length 1.8
  BOTTOM w0.108: C438.2 v1(23.12,27.27) 23.14,27.25 U23.24
N24510304: length 15.1
  BOTTOM w1.016: 150.13,70.3 150.13,55.22
  vias: v1(148.82,54.07) v1(149.2,53.48) v1(149.45,54.32) v1(149.84,53.76) v1(150.17,54.32) v1(150.17,53.2)
N24601108: length 2.7
  TOP w0.102: TP8.1 135.12,41.5 134.3,40.68
  TOP w0.108: U9.113 134.3,40.68
N24628331: length 4.4
  TOP w0.108: Q54.2 61.24,95.67 C839.1 v1(59.93,96.93) 60.22,97.22 R780.1
N24651621: length 1.1
  BOTTOM w0.108: T5.1 97.11,73.15 R169.1
N24658073: length 2.6
  TOP w0.108: U9.71 143.85,27.9 144.12,27.63 144.55,27.63 TP63.1
N24658281: length 3.1
  TOP w0.102: U9.69 142.94,27.1
  TOP w0.108: TP64.1 143.61,26.03 143.33,26.3 143.33,26.94 143.17,27.1 142.94,27.1
N24794497: length 5.2
  BOTTOM w0.108: R816.1 110.34,33.78 110.25,33.68 D42.1 110.25,33.11 109.96,32.82 v1(109.96,32.12) 109.96,31.86 109.57,31.47 109.26,31.47 109.26,31.47 108.48,31.47 108.23,31.22 CN11.27
N24883800: length 1.2
  TOP w0.254: U37.3 R1196.1
N24951133: length 6.7
  TOP w0.508: R1188.2 R1189.2 114.59,46.06 v1(114.18,46.06) 112.22,46.06 110.62,47.67 U38.7
N24952012: length 5.3
  TOP w0.203: R433.2 C275.2 v1(115.66,53.82) 114.77,53.82 114.67,53.92 U15.8 114.67,55.2 114.56,55.31 114.28,55.31 114.17,55.21 U15.7
N25329235: length 4.3
  TOP w0.508: CN16.15 13.2,9.65 v1(14.33,10.78) 14.85,11.29 15.74,11.29 R1202.2
N25329238: length 3.2
  TOP w0.508: 14.33,33.32 13.3,34.35 CN16.14 ; 14.33,33.32 R1203.2 ; 14.33,33.32 v1(14.33,33.32)
N25638274: length 7.3
  BOTTOM w0.108: Q21.3 87.58,93.59 v1(87.3,93.31) 86.59,92.6 85.17,92.6 R299.2 83.95,91.38 83.95,89.88
N25841079: length 5.1
  TOP w0.508: Q77.2 24.52,28.29 C874.2 R1205.2 22.47,28.29 22.1,28.67 22.1,29.81 Q78.3
N26412554:
  vias: v1(132.31,97.07) v2(131.92,98.38) v2(131.92,97.62) v2(132.7,98.38) v2(132.7,97.62)
N26412705: length 1.8
  BOTTOM w0.508: PR164.1 v1(135.93,90.44) PC138.2
N26422980: length 1.4
  BOTTOM w0.203: PU5.3 134.96,104.3 135.16,104.1 PR70.1
N26423000: length 25.2
  BOTTOM w0.203: PU5.7 133.36,104.36 133.18,104.18
  BOTTOM w0.254: 133.18,104.18 133.14,104.14 133.14,101.68 132.75,101.3 123.24,101.3 122.14,102.4
  BOTTOM w0.381: PC49.1 128.5,112.58 v1(131.73,112.58) 133.72,112.58 PR68.1
N26432389: length 2.7
  TOP w0.508: PD6.3 139.84,94.69 139.84,93.68 139.46,93.3 PC32.1
N26432391: length 8.5
  TOP w0.508: PD7.2 142.66,91.25 142.96,91.55 142.96,92.44 PC128.2 143.64,93.44 141.55,93.44 141.22,93.77 141.22,95.43 141.41,95.62 PD6.1
N26432399: length 3.8
  TOP w0.508: PC132.1 138.76,91.81 v1(138.76,91.02) 138.76,90.86 139.13,90.5 139.23,90.5 139.24,90.48 139.67,90.48 140.11,90.92 PD7.3
N26432434: length 2.1
  TOP w0.508: PD8.3 v1(139.05,88.84) 138.67,89.22 PC134.1
N26432450: length 8.2
  TOP w0.508: PD7.1 141.39,92.57 141.14,92.32 141.14,88.53 141.49,88.18 PD8.2 v1(143.21,88.18) PC130.2
N26432481: length 4.5
  TOP w0.508: PD8.1 v1(143.18,89.5) 144.26,89.5 PC133.2 144.31,89.99 143.8,90.5 PR162.2
N26437430: length 10.7
  TOP w0.254: PQ33.2 101.07,110.36 101.56,110.85 PR219.1 101.94,110.22 101.9,110.19 PR217.2 101.25,108.74 v1(101.25,108.02) PQ34.2 101.25,103.66 100.64,103.06 PQ35.3
N26437470: length 8.6
  TOP w0.508: PQ33.3 99.4,111.05 v1(100.02,111.66) 103.94,111.66 PR194.2
N102802469: length 1.3
  BOTTOM w0.108: C117.2 129.39,36.8 R249.1
N107989610: length 1.8
  TOP w0.102: C49.1 12.9,18.62 12.27,18 U4.7
N107992729: length 5
  TOP w0.203: U4.39 7.19,14.12 6.6,13.53 6.6,12.84 6.44,12.68 5.38,12.68 5.04,12.34 v1(4.73,12.34) C62.2
N107992826: length 2.4
  TOP w0.203: U4.35 4.89,16 4.49,15.6 4.49,15 4.35,14.85 C57.2
N107992865: length 5.3
  TOP w0.203: U4.37 6.39,14.2 5.39,13.2 4.5,13.2 4.37,13.33 4.37,14.14 4.13,14.38 3.59,14.38 C57.1
N107994632: length 1.8
  TOP w0.203: U4.34 4.75,16.4 4.34,15.99 C52.1
N107996449: length 2.1
  TOP w0.203: C45.2 4.13,19.02 4.55,19.02 4.78,18.8 U4.28
N108778749: length 7.4
  TOP w0.254: R107.1 12.96,29.43 10.8,29.43 v1(10.67,29.3) 10.36,29.61 Q6.5 Q6.2
N111127099: length 2.5
  TOP w0.203: U4.19 8.39,21.55 8.33,21.61 8.33,22.31
  TOP w0.254: C26.1 8.33,22.68 8.33,22.31
N112543597: length 2.5
  TOP w0.108: D16.1 120.2,33.01 R1175.1 R468.2
N112543691: length 2.5
  TOP w0.108: C292.1 124.84,33.5 v1(125.22,33.5) U9.12
N112544291: length 3
  TOP w0.108: U9.117 132.7,40.39 132.89,40.58 133.03,40.58 133.85,41.41 TP61.1
N112544352: length 2.3
  TOP w0.108: TP60.1 125.18,29.39 125.87,28.7 U9.24
N112544364: length 3.3
  TOP w0.108: U9.28 124.68,27.1 124.56,27.22 124,27.22 TP59.1
N112550518: length 2.4
  TOP w0.102: 133.53,22.45 133.67,22.6 133.81,22.6 134.3,23.09 134.3,23.24
  TOP w0.108: 133.53,22.45 TP62.1 ; U9.48 134.3,23.24
N241867701: length 2.7
  BOTTOM w0.254: PC155.2 128.19,110.94 128.55,111.29 v1(129.01,111.29) 129.16,111.29 129.44,111.01 PR192.1
N241897731: length 1.8
  TOP w0.508: PR184.1 40.73,76.29 v1(39.78,76.29) PC146.2
N241913881: length 1
  BOTTOM w0.254: PR206.2 PR205.2
N241915201: length 1
  BOTTOM w0.254: PR208.1 PR209.2
N241918500: length 22.4
  TOP w0.254: v1(115.6,51.63) 116.1,51.63 PR202.1
  IN1 w0.254: v1(115.6,51.63) 115.78,51.63 117.12,50.29 117.12,49.57 117,49.45 117,48.99 117.31,48.68 123.85,48.68 124.11,48.94 124.11,49.47 125.24,50.6 125.24,51.12 125.34,51.22 125.34,52.86 126.29,53.81 128.58,53.81 129.22,53.18 v1(130.39,53.18)
  BOTTOM w0.254: v1(130.39,53.18) 130.27,53.29 PR203.2
N241918800:
  vias: v1(129.92,62.6)

## Copper pours and planes (outline as drawn)
5VUSB_0 on TOP (solid shape): outline of 135 points within 12.55,58.26 20.52,63.82
5VUSB_0 on BOTTOM (solid shape): 15.68,63.05 17.37,63.05 18.11,63.8 19.48,63.8 19.64,63.64 19.64,62.6 20.96,61.28 20.96,58.69 20.51,58.24 20.13,58.24 20.09,58.26 19.85,58.39 19.58,58.31 19.56,58.33 19.56,58.35 19.54,58.35 19.38,58.51 18.87,58.51 18.76,58.62 18.73,58.72 18.81,58.8 18.96,58.88 19.06,59.03 19.12,59.08 19.2,59.09 19.84,59.25 19.87,59.92 19.86,59.95 19.87,59.98 19.95,60.4 19.71,60.76 19.69,60.81 19.69,61.31 19.31,61.69 16.26,61.69 15.5,62.45 14.1,62.45 13.74,62.09 12.96,62.09 12.55,62.5 12.55,63.16 13.23,63.85 14.88,63.85
5VUSB_1 on BOTTOM (solid shape): outline of 202 points within 149.86,100.09 156.2,105.45
+1.5V on BOTTOM (solid shape): 14.39,20.29 14.46,20.25 14.49,20.18 14.62,19.86 14.95,19.79 14.96,19.8 15.12,19.8 15.16,19.78 15.17,19.75 15.17,18.91 15.13,18.87 15.1,18.85 15.06,18.86 15.05,18.87 14.66,18.96 14.43,18.64 14.43,18.62 14.4,18.59 13.7,18.59 13.32,18.97 13.32,19.86 13.74,20.29
+1.05V_S5 on TOP (solid shape): 74.42,73.83 74.42,73.45 74.48,73.39 74.53,73.33 74.58,73.29 74.63,73.24 75.03,73.24 75.13,73.14 75.9,73.14 76.07,72.96 76.07,72.43 76.18,72.33 76.46,72.33 76.63,72.15 76.63,71.72 76.48,71.57 75.8,71.57 75.57,71.65 75.34,71.57 75.04,71.57 74.81,71.65 74.59,71.57 74.28,71.57 74.18,71.63 74.06,71.65 74.04,71.65 73.78,71.91 73.78,72.13 73.55,72.35 73.48,72.35 73.2,72.35 73.03,72.53 73.03,73.78 73.15,73.9 74.35,73.9
+1.05V_S5 on TOP (solid shape): outline of 678 points within 59.39,84.42 81.38,93.69
+1.05V_S5 on BOTTOM (solid shape): 97.14,96.71 97.16,96.71 97.18,96.69 97.48,96.53 97.78,96.69 97.8,96.71 97.82,96.71 99.26,96.71 99.41,96.56 99.41,92.77 99.16,92.52 94.29,92.52 93.85,92.95 93.85,96.28 94.29,96.71
+1.05V_S5 on BOTTOM (solid shape): 76.46,92.46 77.96,92.46 78.18,92.24 78.18,91.94 78.07,91.82 77.01,91.82 76.93,91.74 76.53,91.74 75.59,90.8 70.08,90.8 69.83,91.04 69.82,91.08 69.83,91.11 69.91,91.39 69.79,91.67 69.78,91.68 69.77,91.7 69.77,91.94 69.93,92.09 70.24,92.09 70.32,92.05 70.34,91.97 70.52,91.54 70.99,91.52 71.01,91.52 71.04,91.52 71.1,91.46 71.54,91.46 71.81,91.56 71.96,91.81 72.01,91.87 72.08,91.89 72.17,91.88 72.25,91.9 72.33,91.9 72.38,91.85 72.7,91.6 73.09,91.72 73.12,91.75 73.16,91.77 73.2,91.75 73.23,91.72 73.59,91.59 73.91,91.8 73.97,91.84 74.04,91.84 74.34,91.84 74.54,92.06 74.56,92.08 74.59,92.09 74.78,92.09 75.21,92.52 76.4,92.52
+1.05V_S5 on BOTTOM (solid shape): outline of 88 points within 71.2,70.73 76.15,73.9
+1.05V_S5 on VCC (solid shape): outline of 8184 points within 63.12,71.14 97.92,95.21
+1.05V_S5 on IN1 (solid shape): outline of 1375 points within 68.77,73.37 80.87,92.47
+1.8V_EMMC on TOP (solid shape): 115.6,78.55 115.6,78.1 114.99,77.49 114.99,77.16 114.98,77.14 114.97,77.12 114.93,76.68 115.35,76.53 115.37,76.53 115.4,76.52 115.56,76.35 115.56,76.06 115.43,75.92 114.9,75.92 114.2,76.62 114.2,77.51 113.87,77.84 113.87,78.5 114.07,78.7 115.44,78.7
+1.8V_EMMC on TOP (solid shape): outline of 93 points within 118.39,75.97 121.77,79.01
+1.8V_EMMC on BOTTOM (solid shape): 121.46,77.87 121.46,76.73 121.69,76.49 121.69,76.19 121.59,76.09 120.93,76.09 120.45,76.57 120.41,76.57 120.36,76.62 120.25,76.62 120.2,76.62 120.18,76.62 120.16,76.63 120.04,76.75 120.04,76.93 120.22,77.1 120.38,77.1 120.41,77.1 120.43,77.08 120.95,77.07 120.76,77.56 120.75,77.57 120.68,77.64 120.19,77.64 120.07,77.77 120.07,78.02 120.17,78.12 121.21,78.12
+1.8V_EMMC on IN1 (solid shape): outline of 267 points within 114.94,75.28 119.03,77.64
+1.8V_S5 on TOP (solid shape): 95.05,68.72 95.05,68.32 95.04,68.3 95.03,68.28 94.98,68.24 94.83,68.09 94.83,67.33 94.69,67.2 94.09,67.2 94.01,67.28 94.01,67.28 93.95,67.34 93.95,68.44 93.88,68.52 93.88,68.8 94.03,68.95 94.82,68.95
+1.8V_S5 on TOP (solid shape): outline of 247 points within 88.45,63.8 93.04,69.76
+1.8V_S5 on TOP (solid shape): outline of 1221 points within 85.27,75.77 100.51,98.64
+1.8V_S5 on BOTTOM (solid shape): 99.16,111.79 99.16,108.3 97.89,107.03 97.89,104.49 97.38,103.98 97,103.98 96.75,103.72 95.66,103.72 95.25,104.13 95.25,105.93 95.27,105.97 95.3,105.98 96.52,105.98 96.52,111.8 96.86,112.14 98.81,112.14
+1.8V_S5 on BOTTOM (solid shape): 86,88.84 86.36,88.74 86.61,89 86.66,89.04 89.74,89.04 89.94,88.84 89.94,88.04 89.79,87.89 85,87.89 84.89,88 84.89,88.33 84.71,88.51 84.71,88.94 84.81,89.04 85.8,89.04
+1.8V_S5 on BOTTOM (solid shape): 117.11,105.93 118.2,105.93 118.28,105.86 118.28,103.61 118.16,103.5 117.4,103.5 117.37,103.47 117.37,103.42 117.13,103.17 117.02,103.17 116.74,103.04 116.66,102.74 116.66,102.72 116.65,102.69 116.4,102.44 115.38,102.44 115.37,102.45 115.37,102.59 115.38,102.63 115.42,102.64 116.36,102.64 116.36,102.84 115.42,102.84 115.38,102.86 115.37,102.89 115.37,103.01 115.04,103.34 114.89,103.34 114.87,103.36 114.87,104.34 114.88,104.35 115.51,104.35 115.96,104.8 115.96,105.36 115.95,105.37 115.95,106.11 116.04,106.2 116.84,106.2
+1.8V_S5 on BOTTOM (solid shape): 51.84,75.89 51.84,73.08 51.82,73.05 51.8,73.04 51.48,72.69 51.8,72.33 51.83,72.31 51.84,72.27 51.84,69.87 51.51,69.54 51.21,69.54 51.19,69.52 51.13,69.52 50.82,69.21 50.82,68.93 50.55,68.67 50.12,68.67 50.01,68.77 50.01,69.29 50.02,69.31 50.03,69.33 50.13,69.59 50.03,69.84 50.02,69.86 50.01,69.88 50.01,71.8 50.05,71.83 50.05,72.25 50.04,72.33 50.01,72.42 50.01,74.64 50.12,74.74 50.12,74.77 50.12,74.79 50.14,74.81 50.31,75.17 50.05,75.47 50.03,75.48 50.01,75.5 50.01,75.73 50.45,76.16 51.56,76.16
