# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A1: length 75
  TOP w0.089: v1(79.21,61.39) 79.62,61.8 79.62,62.71 79.53,62.8 79.38,62.8 79.29,62.71 79.29,62.59 79.21,62.51 79.05,62.51 78.97,62.59 78.97,62.72 78.89,62.8 78.76,62.8 78.65,62.69 78.65,59.53 78.54,59.42 78.09,59.42 78.01,59.35 78.01,59.19 78.09,59.12 78.46,59.12 78.53,59.04 78.53,58.89 78.46,58.81 78.09,58.81 78.01,58.74 78.01,58.58 78.09,58.51 78.69,58.51 78.78,58.42 78.78,58.24 78.69,58.16 78.19,58.16 ; U27.P7 100.6,41.71 100.42,41.53 100.33,41.53 100.11,41.31 99.78,41.31 99.39,40.92 99.1,40.92 98.73,40.55 v3(98.65,40.55) ; v3(80.85,40.52) 81.26,40.92 81.98,40.92 U26.P7
  TOP w0.117: 78.19,58.16 78.1,58.07 78.1,57.75 78.24,57.61 79.78,57.61 80.52,56.87 81.14,56.87 81.28,57.01 81.28,57.37 81.41,57.51 81.78,57.51 81.91,57.38 81.91,57 82.04,56.86 82.35,56.86 82.45,56.77 82.45,56.46 82.58,56.33 82.93,56.33 83.06,56.21 83.06,55.88 83.49,55.45 84.32,55.45 84.82,54.95 85.07,54.95 85.19,55.08 85.19,55.8 85.34,55.94 85.79,55.94 85.91,55.83 85.91,55.6 86.05,55.46 86.64,55.46 86.94,55.16 87.1,55.16 88.58,53.67 88.73,53.67 89.54,52.86 89.9,52.86 90.03,52.73 90.03,52.38 90.63,51.79 90.63,44.94 90.27,44.59 90.27,43.46 90.81,42.92 90.81,42.76 90.46,42.41 90.46,42.28 90.24,42.05 90.24,41.54 90.05,41.35 90.05,40.66 90.18,40.53 v1(90.18,40.1) 89.86,39.78 89.86,38.53 R1098.2
  IN2 w0.102: v3(98.65,40.55) 98.43,40.33 97.2,40.33 96.66,39.79 94.48,39.79 94.36,39.9 93.42,39.9 93.02,40.3 92.56,40.3 92.5,40.24 92.16,40.24 91.88,40.52 91.74,40.52 91.62,40.4 91.62,40.24 91.44,40.07 91.21,40.07 91.1,40.17 91.1,40.67 91,40.77 90.73,40.77 90.63,40.67 90.63,40.25 90.48,40.1 v1(90.18,40.1) 89.77,40.1 89.67,39.99 89.05,39.99 88.48,40.55 87.57,40.55 87.4,40.38 86.93,40.38 86.93,40.38 84.78,40.38 84.09,40.38 83.68,40.78 82.87,40.78 82.77,40.88 82.77,41.06 82.66,41.16 82.46,41.16 82.36,41.06 82.36,40.88 82.26,40.78 81.81,40.78 81.67,40.93 81.27,40.93 v3(80.85,40.52)
  BOTTOM w0.089: v3(98.65,40.55) 98.55,40.66 98.55,40.87 98.46,40.96 98.2,40.96 98.07,41.1 98.07,41.72 97.88,41.9 97.54,41.9 U33.P7 ; v1(79.21,61.39) U7.BC12 ; v3(80.85,40.52) 80.85,40.77 80.92,40.84 80.92,40.97 80.78,41.11 80.61,41.11 80.44,40.93 80.28,40.93 80.19,41.02 80.19,41.17 80.11,41.26 80.07,41.26 79.62,41.71 U34.P7
M_B_A2: length 65.8
  TOP w0.089: U26.P3 79.96,41.43 79.96,41.43 80.4,40.98 80.4,40.45 80.48,40.37 80.48,40.36 80.7,40.14 81.01,40.14 81.02,40.15 81.09,40.15 81.48,40.55 v3(81.48,40.55) ; U27.P3 97.67,41.49 98.26,40.9 98.26,40.39 98.48,40.17 98.89,40.17 99.26,40.55 v3(99.26,40.55)
  IN1 w0.135: v1(87.18,56.35) 87.18,56.63 87.36,56.81 88.86,56.81 93.29,52.38 93.29,50.47 93.61,50.15 93.61,48.95 93.61,48.4 93.62,47.2 93.38,46.97 93.38,46.2 93.38,44.1 93.5,43.99 93.5,43.59 93.19,43.28 93.19,41.9 93.02,41.72 92.71,41.72 92.53,41.54 92.53,41.19 92.71,41.01 93.02,41.01 93.19,40.83 93.19,40.36 v1(92.72,39.89)
  IN2 w0.102: v3(99.26,40.55) 99.4,40.69 99.54,40.69 99.74,40.49 100.11,40.49 100.22,40.39 100.22,39.96 100.11,39.86 99.94,39.86 99.64,40.15 99.2,40.15 99.08,40.02 98.9,40.02 98.81,40.11 98.07,40.11 97.97,40.01 97.97,39.68 97.88,39.58 97.61,39.58 97.51,39.69 97.51,40 97.41,40.1 97.27,40.1 97.11,39.94 97.11,39.69 97.01,39.58 94.36,39.58 94.24,39.7 92.92,39.7 v1(92.72,39.89) 92.37,39.89 92.3,39.82 91.98,39.82 91.96,39.84 90.5,39.84 90.35,39.69 90.02,39.69 89.99,39.72 88.93,39.72 88.33,40.32 87.62,40.32 87.48,40.17 87.36,40.17 87.35,40.18 87.02,40.18 87.01,40.17 83.72,40.17 83.34,40.55 v3(81.48,40.55)
  BOTTOM w0.089: U7.BJ6 81.93,58.45 81.93,57.52 82.89,56.56 83.96,56.56 84.16,56.35 v1(87.18,56.35) ; v3(81.48,40.55) 81.41,40.55 81.21,40.75 81.21,40.9 81.33,41.01 81.98,41.01 82.12,41.16 82.12,41.28 82.01,41.4 82.01,41.52 82.14,41.65 82.26,41.65 82.4,41.5 82.55,41.5 U34.P3 ; U33.P3 100.49,41.88 100.36,41.88 100.07,41.58 99.75,41.58 99.68,41.51 99.68,41.21 99.43,40.96 99.14,40.96 99.07,41.04 98.96,41.04 98.88,40.96 98.88,40.85 99,40.73 99.08,40.73 v3(99.26,40.55)
  BOTTOM w0.114: R1083.2 92.72,39.28 v1(92.72,39.89)
M_B_A3: length 66.2
  TOP w0.089: U27.N2 97.03,42.14 97.66,42.14 98.01,41.79 98.01,41.43 98.47,40.96 98.87,40.96 v3(99.28,41.37) ; v3(81.53,41.39) 81.25,41.12 81.12,41.12 81.09,41.09 80.78,41.09 80.76,41.12 80.74,41.12 80.35,41.5 80.17,41.5 79.94,41.73 79.94,41.9 79.75,42.09 79.27,42.09 79.2,42.01 79.07,42.01 78.82,42.26 U26.N2
  IN1 w0.135: v1(91.88,40.97) 91.88,41.31 91.62,41.57 91.62,42.37 91.95,42.7 91.95,44.26 92.06,44.38 92.06,45.65 92.06,45.65 92.06,46.9 91.72,47.24 91.72,48.16 92.25,48.69 92.25,49.64 91.97,49.92 91.97,51.77 89.9,53.84 88.98,53.84 88.77,54.05 88.77,54.57 88.58,54.76 88.24,54.76 88.13,54.88 86.81,54.88 86.77,54.92 86.53,54.92 85.18,56.26 84.82,56.26 84.64,56.08 84.64,55.76 v1(84.76,55.64)
  IN2 w0.102: v3(99.28,41.37) 99.28,41.04 99.18,40.93 98.31,40.93 98.12,41.13 97.97,41.13 97.87,41.03 97.87,40.66 97.75,40.54 97.48,40.54 97.37,40.66 97.37,40.97 97.25,41.08 97.1,41.08 96.85,40.83 96.85,40.27 96.57,39.99 94.77,39.99 94.58,40.18 94.58,40.34 94.46,40.47 94.28,40.47 94.18,40.36 94.18,40.21 94.07,40.11 93.52,40.11 92.56,41.07 92.26,41.07 92.17,40.97 v1(91.88,40.97) 90.22,40.97 90,40.76 89.45,40.76 89.41,40.79 87.53,40.79 87.31,40.58 86.85,40.58 86.85,40.58 84.24,40.58 83.41,41.41 81.53,41.41 81.53,41.4 v3(81.53,41.39)
  BOTTOM w0.089: v3(81.53,41.39) 82.13,42 82.13,42.33 82.23,42.43 82.47,42.43 82.56,42.34 82.56,42.19 82.65,42.1 82.97,42.1 83.19,42.31 83.19,42.75 83.31,42.87 83.51,42.87 83.62,42.77 U34.N2 ; U7.BH7 81,59.02 80.88,59.02 80.8,58.94 80.8,58.94 80.65,58.79 80.65,57.96 80.88,57.73 81,57.73 83.35,55.38 84.5,55.38 v1(84.76,55.64) ; v3(99.28,41.37) 99.36,41.46 99.36,41.47 99.78,41.89 100.02,41.89 100.22,42.09 101.04,42.09 101.13,42.18 101.13,42.32 100.99,42.45 100.99,42.86 101.15,43.02 101.28,43.02 101.4,42.91 101.4,42.57 U33.N2
  BOTTOM w0.117: v1(91.88,40.97) 91.88,40.42 92.02,40.28 R1081.2
M_B_A4: length 76.1
  TOP w0.089: U26.P8 83.21,41.35 82.72,41.35 82.2,40.84 82.2,40.29 82.08,40.18 81.38,40.18 80.92,39.72 v3(80.86,39.72) ; v3(98.67,39.72) 98.7,39.72 99.16,40.18 99.43,40.18 99.57,40.31 99.92,40.31 100.27,40.66 100.27,41.1 100.52,41.35 100.98,41.35 U27.P8 ; v1(79.21,60.68) 79.21,60.78 79.44,61.01 79.56,61.01 79.78,60.79 79.78,60.53 79.62,60.36 79.62,60.23 79.78,60.06 79.78,59.94 78.82,58.98 78.82,58.82 78.93,58.71 79.06,58.71 79.86,59.52 79.99,59.52 80.11,59.39 80.11,59.26 79.44,58.59 79.44,58.45 79.56,58.33 79.68,58.33 80.42,59.07 80.61,59.07 80.74,58.94 80.74,58.82 79.95,58.03 79.95,57.87 80.12,57.7 80.29,57.7 80.53,57.94 80.7,57.94 80.91,57.72 81.27,57.72 81.51,57.97 81.51,58.32 81.59,58.39 81.84,58.39
  TOP w0.117: v1(90.52,39.32) 90.68,39.32 90.81,39.45 90.81,40.1 90.53,40.38 90.53,41.95 90.74,42.16 90.74,42.29 91.16,42.71 91.16,44.1 91.16,44.1 91.16,44.5 90.91,44.74 90.91,51.9 90.31,52.5 90.31,52.68 90.61,52.98 90.61,53.13 90.33,53.42 90.12,53.42 89.84,53.14 89.66,53.14 88.85,53.95 88.8,53.95 87.31,55.44 87.1,55.44 86.31,56.22 84.53,56.22 84.03,55.73 83.61,55.73 83.36,55.98 83.36,56.31 81.97,57.7 81.97,58.26 81.84,58.39
  IN2 w0.102: v3(98.67,39.72) 98.48,39.91 98.32,39.91 98.17,39.76 98.17,39.48 98.07,39.38 94.23,39.38 94.13,39.47 92.59,39.47 92.57,39.49 92.56,39.49 92.47,39.57 92.35,39.57 92.24,39.47 92.24,39.07 92.14,38.96 91.91,38.96 91.85,39.03 91.85,39.3 91.82,39.32 91.82,39.51 91.7,39.63 91.37,39.63 91.18,39.44 91.02,39.44 90.83,39.63 90.62,39.63 90.52,39.52 v1(90.52,39.32) 90.14,39.32 90.1,39.36 84.01,39.36 83.27,40.1 81.23,40.1 80.86,39.72 v3(80.86,39.72)
  BOTTOM w0.089: U33.P8 96.6,41.38 96.69,41.28 97.1,41.28 97.24,41.42 97.67,41.42 97.85,41.24 97.85,40.71 98.63,39.93 98.63,39.75 v3(98.67,39.72) ; U7.BD12 v1(79.21,60.68) ; U34.P8 78.82,41.42 79.13,41.11 79.27,41.11 79.47,41.32 79.74,41.32 79.97,41.09 79.97,40.86 79.9,40.79 79.9,40.73 80.02,40.6 80.15,40.6 80.25,40.7 80.37,40.7 80.46,40.61 80.46,40.11 80.85,39.72 v3(80.86,39.72)
  BOTTOM w0.117: R1080.2 90.45,39.38 v1(90.52,39.32)
M_B_A5: length 74.2
  TOP w0.089: v3(99.31,39.72) 98.94,39.34 98.41,39.34 98.04,39.72 98.04,40.79 97.5,41.33 97.04,41.33 U27.P2 ; U26.P2 79.11,41.48 79.11,41.47 79.26,41.33 79.72,41.33 80.16,40.89 80.16,40.38 80.25,40.29 80.25,39.93 80.48,39.71 80.48,39.5 80.63,39.34 81.16,39.34 v3(81.53,39.72)
  TOP w0.117: v1(83.78,56.15) 84.15,56.52 86.63,56.52 86.76,56.39 86.76,56.18 87,55.93 87.28,55.93 88.48,54.74 89.4,54.74 89.77,54.37 89.77,54.19 89.5,53.91 89.5,53.73 89.68,53.55 89.86,53.55 90.13,53.83 90.31,53.83 91.21,52.94 91.21,44.87 91.44,44.64 91.44,43.99 91.44,43.98 91.44,42.6 91.02,42.18 91.02,42.05 90.81,41.83 90.81,40.57 91.09,40.29 91.09,39.48 v1(91.44,39.13) 90.42,38.11 90.42,37.38 90.03,36.99 89.73,36.99 R1099.2
  IN2 w0.102: v3(99.31,39.72) 99.48,39.88 99.62,39.88 99.7,39.8 99.7,39.5 99.48,39.27 98.43,39.27 98.3,39.14 94.12,39.14 94,39.27 92.55,39.27 92.45,39.17 92.45,38.86 92.34,38.76 91.54,38.76 91.44,38.86 v1(91.44,39.13) 90.99,39.13 90.77,38.91 90.23,38.91 90,39.14 87.07,39.14 87.06,39.16 86.43,39.16 86.41,39.14 83.51,39.14 83.19,39.46 82.7,39.46 82.6,39.57 82.6,39.78 82.5,39.88 82.29,39.88 82.19,39.78 82.19,39.57 82.09,39.46 81.79,39.46 v3(81.53,39.72)
  BOTTOM w0.089: U33.P2 101.4,41.45 101.08,41.14 100.9,41.14 100.62,41.42 100.39,41.42 100.22,41.24 100.22,41.09 100.27,41.05 100.27,40.74 100.21,40.68 100.21,40.59 99.8,40.18 99.06,40.18 98.97,40.09 98.97,39.96 99.21,39.72 v3(99.31,39.72) ; v3(81.53,39.72) 81.4,39.72 81.2,39.92 81.2,40.06 81.29,40.15 81.61,40.15 81.65,40.11 81.98,40.11 82.07,40.2 82.07,40.35 81.88,40.54 81.88,40.69 81.98,40.79 82.13,40.79 82.19,40.73 82.38,40.73 82.47,40.82 82.47,41.11 82.68,41.33 83.18,41.33 U34.P2 ; v1(83.78,56.15) 83.9,56.03 84.24,56.03 84.35,55.93 84.35,55.74 84.22,55.61 83.46,55.61 83.17,55.9 83.17,56.2 83.02,56.35 82.72,56.35 81.52,57.55 81.52,57.7 81.71,57.89 81.71,58.05 81.52,58.24 81.52,58.39 81.38,58.54 81.38,58.54 81.37,58.55 81.37,58.92 81.46,59.01 81.76,59.01 81.85,59.1 U7.BH6
M_B_A6: length 77.2
  TOP w0.089: 81.16,59.07 81.16,59.07 80.81,59.42 80.81,59.9 80.58,60.14 80.58,60.52 81.09,61.04 81.09,61.43 v1(80.81,61.71) ; U26.R8 83.23,40.58 83.23,39.11 81.72,37.61 81.44,37.61 81.26,37.43 81.13,37.43 v3(80.91,37.21) ; U27.R8 101.07,40.64 101.01,40.58 101.01,39.11 99.53,37.64 99.17,37.64 98.77,37.24 v1(98.69,37.24)
  TOP w0.117: R1084.2 90.58,36.86 v1(90.95,37.23) 91.24,36.94 91.47,36.94 91.64,37.11 91.64,37.68 91.53,37.79 91,37.79 90.88,37.92 90.88,38.16 91.03,38.32 91.21,38.32 91.86,38.96 91.86,39.44 91.39,39.91 91.39,40.39 91.09,40.69 91.09,41.74 91.29,41.94 91.29,42.07 91.71,42.49 91.71,44.81 91.48,45.04 91.48,53.07 89.52,55.03 88.6,55.03 87.7,55.93 87.7,56.43 87.33,56.8 83.27,56.8 82.24,57.84 82.24,58.45 81.62,59.07 81.16,59.07
  IN2 w0.102: v3(80.91,37.21) 81.29,37.59 82.03,37.59 82.37,37.24 87.66,37.24 87.77,37.13 90.85,37.13 v1(90.95,37.23) 90.96,37.24 92.58,37.24 92.82,37 92.89,37 92.91,36.98 93.37,36.98 94.03,36.32 94.85,36.32 94.95,36.22 94.95,36.02 95.06,35.92 95.26,35.92 95.36,36.02 95.36,36.22 95.46,36.32 96.63,36.32 96.73,36.22 96.73,36.09 96.83,35.99 97.03,35.99 97.13,36.09 97.13,36.22 97.24,36.32 97.41,36.32 98.32,37.24 v1(98.69,37.24)
  BOTTOM w0.089: U33.R8 96.95,40.61 96.95,39.08 97.65,38.38 97.8,38.38 97.92,38.51 98.07,38.51 98.17,38.4 98.17,38.26 98.05,38.13 98.05,37.88 v1(98.69,37.24) ; v3(80.91,37.21) 80.31,37.81 80.05,37.81 79.65,38.21 79.65,38.37 79.51,38.51 79.27,38.51 79.27,38.51 79.14,38.51 79.02,38.64 79.02,38.76 79.19,38.94 79.19,39.06 79.18,39.08 79.18,40.61 U34.R8 ; v1(80.81,61.71) 80.52,62.05 U7.BB8
M_B_A7: length 78.6
  TOP w0.089: v3(99.4,37.25) 99.38,37.25 98.99,36.86 98.44,36.86 96.95,38.35 96.95,40.61 96.93,40.63 U27.R2 ; 81.8,59.32 81.27,59.32 80.99,59.6 v1(80.99,60.31) ; v3(81.67,37.15) 81.47,36.95 81.22,36.95 81.1,36.83 80.75,36.83 79.18,38.4 79.18,40.61 U26.R2
  TOP w0.117: R1096.2 91.63,36.49 v1(91.83,36.69) 91.93,36.79 91.93,38.6 92.31,38.98 92.31,39.37 91.66,40.03 91.66,40.51 91.36,40.8 91.36,41.59 91.57,41.8 91.57,41.8 91.64,41.88 91.64,42 91.9,42.26 91.91,42.26 92,42.35 92,43.75 92,44.8 92,44.8 92,44.91 91.76,45.14 91.76,53.17 89.63,55.3 88.72,55.3 87.97,56.04 87.97,56.57 87.45,57.09 84.55,57.09 84.01,57.63 84.01,58.4 83.67,58.74 82.38,58.74 81.8,59.32
  IN2 w0.102: v3(99.4,37.25) 99.4,36.96 99.27,36.83 98.28,36.83 97.16,35.71 96.67,35.71 96.49,35.89 95.66,35.89 95.48,35.71 94.94,35.71 94.54,36.12 93.77,36.12 93.62,35.97 93.62,35.67 93.52,35.57 93.27,35.57 93.17,35.67 93.17,36.7 93.09,36.78 92.83,36.78 92.81,36.79 92.7,36.79 92.46,37.04 92.18,37.04 v1(91.83,36.69) 91.5,36.69 91.39,36.81 82.4,36.81 82.06,37.15 v3(81.67,37.15)
  BOTTOM w0.089: U34.R2 83.26,40.61 83.26,40.09 83.06,39.89 83.06,39.65 83.25,39.47 83.25,38.98 83,38.73 83,38.6 83.15,38.45 83.15,38.32 83.03,38.2 82.9,38.2 82.75,38.35 82.62,38.35 82.49,38.22 82.49,38.1 82.65,37.94 82.65,37.82 82.52,37.69 82.4,37.69 82.24,37.85 82.12,37.85 81.95,37.68 81.95,37.45 81.67,37.16 81.67,37.15 v3(81.67,37.15) ; U33.R2 101.04,40.61 101.04,40.09 100.84,39.89 100.84,39.65 100.94,39.55 101.07,39.55 101.18,39.45 101.18,39.3 101.07,39.19 100.94,39.19 100.84,39.09 100.84,38.65 100.95,38.54 100.95,38.4 100.84,38.29 100.7,38.29 100.6,38.39 100.45,38.39 100.35,38.28 100.35,38.14 100.42,38.06 100.42,37.91 100.32,37.81 100.2,37.81 100.1,37.91 99.88,37.91 99.73,37.76 99.73,37.45 99.54,37.25 99.4,37.25 v3(99.4,37.25) ; U7.BE8 v1(80.99,60.31)
M_B_A8: length 83.7
  TOP w0.089: 83.04,61.18 82.58,61.64 82.58,61.83 82.56,61.85 82.56,61.85 82.32,62.09 82.29,62.12 80.35,62.12 79.8,61.57 79.8,61.09 v1(80.2,60.69) ; v3(80.8,36.35) 80.99,36.54 81.27,36.54 81.42,36.7 81.43,36.7 81.44,36.71 81.76,36.71 82.04,36.99 82.04,37.54 83.62,39.11 U26.T8 ; v3(98.64,36.45) 98.85,36.45 99.23,36.83 100.2,36.83 101.4,38.03 U27.T8
  TOP w0.117: 83.04,61.18 83.1,61.18 86.63,57.65 88.07,57.65 92.4,53.32 92.4,47.88 92.39,47.86 92.39,47.52 92.4,47.5 92.4,45.52 92.56,45.37 92.56,43.63 93.32,42.87 93.32,40.71 93.46,40.57 93.46,39.26 92.86,38.66 92.86,37.74 92.65,37.53 92.65,36.41 v1(92.67,36.39) 92.72,36.34 92.98,36.34 93.41,35.91 R1101.2
  IN2 w0.102: v3(80.8,36.35) 81.17,36.72 82.09,36.72 82.36,36.45 90.6,36.45 91.05,36.01 91.77,36.01 92.16,36.39 v1(92.67,36.39) 92.89,36.18 92.89,35.65 92.76,35.53 91.77,35.53 91.67,35.42 91.67,35.17 91.77,35.07 95.12,35.07 95.74,35.69 96.41,35.69 96.69,35.4 97.1,35.4 97.42,35.08 97.64,35.08 97.75,35.2 97.75,35.99 97.88,36.12 98.09,36.12 98.19,36.02 98.19,35.46 98.3,35.35 98.47,35.35 98.64,35.52 v3(98.64,36.45)
  BOTTOM w0.089: U7.BD10 v1(80.2,60.69) ; v3(80.8,36.35) 80.5,36.66 80.5,36.95 80.33,37.12 80.04,37.12 79.9,37.25 79.9,37.54 79.82,37.63 79.53,37.63 79.4,37.75 79.4,37.88 79.47,37.95 79.47,38.08 79.35,38.21 79.22,38.21 79.15,38.13 79.02,38.13 78.82,38.34 U34.T8 ; v3(98.64,36.45) 97.75,37.34 97.74,37.34 97.65,37.43 97.65,37.44 97.64,37.45 97.64,37.58 97.75,37.68 97.75,37.85 97.66,37.94 97.5,37.94 97.39,37.83 97.27,37.83 97.14,37.95 97.14,38.08 97.25,38.19 97.25,38.31 97.12,38.44 97,38.44 96.89,38.33 96.76,38.33 96.6,38.5 96.6,40.17 U33.T8
M_B_A9: length 71.8
  TOP w0.089: U27.R3 97.4,40.72 97.79,40.33 97.79,39.25 98.52,38.51 98.53,38.51 98.54,38.5 98.85,38.5 99.23,38.89 v3(99.32,38.89) ; U26.R3 79.62,40.62 79.94,40.3 79.94,40.03 79.73,39.82 79.73,39.37 80.59,38.51 81.12,38.51 81.5,38.89 v3(81.54,38.89)
  TOP w0.117: R1079.2 93.87,36.71 93.87,37.85 v1(93.28,38.43)
  IN1 w0.089: 86.2,59.29 v1(85.63,59.85)
  IN1 w0.135: v1(93.28,38.43) 92.88,38.83 92.88,39.21 93.61,39.94 93.61,43.23 93.83,43.45 93.83,44.13 93.8,44.15 93.71,44.24 93.71,46.34 93.71,46.83 93.95,47.06 93.95,50.31 93.64,50.62 93.64,52.63 93.28,52.98 89.06,57.2 87.09,57.2 86.25,58.04 86.25,59.24 86.2,59.29
  IN2 w0.102: v3(99.32,38.89) 99.4,38.96 99.68,38.96 99.85,38.8 100,38.8 100.14,38.66 100.14,38.24 99.99,38.09 99.81,38.09 99.7,38.2 99.7,38.22 99.45,38.47 99.43,38.47 99.41,38.49 98.48,38.49 98.07,38.09 97.68,38.09 97.58,37.98 97.58,37.76 97.49,37.67 94.77,37.67 94.67,37.57 94.67,37.25 94.55,37.13 94.32,37.13 94.21,37.23 94.21,38.3 94.11,38.4 93.87,38.4 93.77,38.3 93.77,38.11 93.67,38.01 93.54,38.01 93.28,38.26 v1(93.28,38.43) 93.2,38.43 93.17,38.4 92.97,38.4 92.91,38.34 87.3,38.34 87.1,38.14 86.51,38.14 86.1,38.55 82.96,38.55 82.62,38.89 v3(81.54,38.89)
  BOTTOM w0.089: U7.BE2 84.03,60.87 84.39,60.87 84.67,60.59 85.01,60.59 85.63,59.96 v1(85.63,59.85) ; U34.R3 82.82,40.97 82.82,40.63 82.71,40.52 82.58,40.52 82.27,40.21 82.27,40.08 82.58,39.77 82.58,39.62 82.48,39.52 82.33,39.52 82.2,39.66 82.02,39.66 81.89,39.52 81.89,39.34 82.11,39.12 82.11,38.94 81.92,38.75 81.68,38.75 v3(81.54,38.89) ; U33.R3 100.6,40.97 100.6,40.64 99.86,39.9 99.86,39.73 99.95,39.64 100.17,39.64 100.39,39.42 100.39,39.02 100.14,38.78 99.43,38.78 v3(99.32,38.89)
M_B_A10: length 60.8
  TOP w0.089: v3(98.45,43.94) 98.46,43.93 98.46,43.77 98.55,43.68 98.82,43.68 98.94,43.56 99.07,43.56 99.21,43.71 99.65,43.71 99.93,44 100.25,44 100.36,43.88 100.48,43.88 100.6,43.99 U27.L7 ; U26.L7 82.68,44.17 81.85,44.99 81.49,44.99 81.31,44.8 81.31,44.64 81.1,44.43 80.96,44.43 80.71,44.19 80.49,44.19 v3(80.48,44.18)
  IN1 w0.135: v1(85.61,55.11) 86.13,54.59 86.63,54.59 86.67,54.55 87.99,54.55 88.11,54.43 88.31,54.43 88.44,54.3 88.44,53.91 88.84,53.51 89.76,53.51 91.64,51.63 91.64,49.79 91.92,49.5 91.92,48.83 91.39,48.29 91.39,47.11 91.73,46.76 91.73,45.52 91.73,44.51 91.62,44.4 91.62,42.84 91.3,42.52 90.89,42.52 90.72,42.7 v1(90.72,43.64)
  IN2 w0.102: v3(98.45,43.94) 98.33,44.06 97.61,44.06 97.48,43.93 95.66,43.93 95.26,44.34 94.14,44.34 93.86,44.62 92.1,44.62 92.02,44.53 92.02,43.72 91.91,43.61 91.69,43.61 91.6,43.7 91.6,44.5 91.49,44.62 91.29,44.62 91.18,44.51 91.18,43.76 91.06,43.64 90.72,43.64 v1(90.72,43.64) 90.71,43.64 90.22,44.14 88.83,44.14 88.57,43.88 82.69,43.88 82.38,44.19 81.42,44.19 81.37,44.24 81.36,44.24 81.35,44.25 80.55,44.25 80.48,44.18 v3(80.48,44.18)
  BOTTOM w0.089: v1(85.61,55.11) 85.21,55.11 85.15,55.17 83.28,55.17 81.53,56.92 80.67,56.92 80.22,57.37 80.22,58.43 80.15,58.51 U7.BJ9 ; v3(98.45,43.94) 98.71,44.2 98.71,44.38 98.3,44.8 98.03,44.8 97.96,44.73 97.96,44.61 98.07,44.5 98.07,44.37 97.94,44.25 97.82,44.25 97.71,44.35 97.58,44.35 U33.L7 ; v3(80.48,44.18) 80.47,44.17 80.43,44.17 80.2,43.95 80.2,43.79 80.11,43.7 79.46,43.7 79.31,43.55 79.17,43.55 79.01,43.72 79.01,43.9 79.14,44.03 79.14,44.24 79.22,44.33 79.46,44.33 U34.L7
  BOTTOM w0.117: R1085.2 91.07,43.29 90.72,43.64 v1(90.72,43.64)
M_B_A11: length 74.8
  TOP w0.089: v3(80.9,38.88) 80.97,38.88 81.43,39.34 81.69,39.34 81.69,39.35 82,39.35 82.44,39.8 82.44,40.59 U26.R7 ; U27.R7 100.6,40.97 100.6,40.64 100.22,40.26 100.22,40.06 99.5,39.34 99.2,39.34 98.99,39.13 98.95,39.13 v3(98.69,38.88)
  TOP w0.117: v1(93.87,38.83) 94.38,38.31 94.38,37.23 R1089.2
  IN1 w0.089: 85.09,60.63 84.97,60.63 84.96,60.63 84.63,60.63 84.39,60.86 84.39,60.95 83.73,61.61 83.73,61.62 83.26,62.09 82.56,62.09 v1(82.16,61.69)
  IN1 w0.135: v1(93.87,38.83) 93.99,38.95 93.99,41.15 93.98,41.16 93.98,41.52 93.99,41.53 93.99,43.15 94.16,43.32 94.16,44.26 94.13,44.29 94.04,44.38 94.04,46.69 94.28,46.92 94.28,50.45 93.97,50.76 93.97,52.76 89.17,57.56 88.03,57.56 86.59,59 86.59,59.52 85.48,60.63 85.09,60.63
  IN2 w0.102: v3(98.69,38.88) 98.63,38.94 98.2,38.94 98.09,38.84 98.09,38.39 97.99,38.29 97.8,38.29 97.69,38.4 97.69,38.84 97.59,38.94 97.38,38.94 97.28,38.84 97.28,37.98 97.18,37.88 96.98,37.88 96.87,37.98 96.87,38.84 96.77,38.94 96.57,38.94 96.47,38.84 96.47,37.98 96.37,37.88 96.16,37.88 96.06,37.98 96.06,38.84 95.96,38.94 95.76,38.94 95.66,38.84 95.66,37.98 95.55,37.88 95.35,37.88 95.25,37.98 95.25,38.84 95.15,38.94 94.94,38.94 94.84,38.84 94.84,37.98 94.74,37.88 94.54,37.88 94.44,37.98 94.44,38.84 94.33,38.94 94.04,38.94 94.03,38.95 93.99,38.95 v1(93.87,38.83) 93.85,38.84 92.74,38.84 92.46,38.56 90.19,38.56 89.87,38.88 87.05,38.88 86.97,38.95 86.51,38.95 86.43,38.88 83.2,38.88 82.83,39.25 81.72,39.25 81.68,39.28 81.3,39.28 v3(80.9,38.88)
  BOTTOM w0.089: v3(80.9,38.88) 80.68,39.11 80.02,39.11 79.95,39.17 79.95,39.17 79.73,39.39 79.73,39.73 79.97,39.96 79.97,40.31 79.76,40.52 79.69,40.52 79.62,40.59 U34.R7 ; v3(98.69,38.88) 98.25,39.32 97.96,39.32 97.85,39.43 97.85,39.65 97.98,39.78 98.05,39.78 98.18,39.91 98.18,40.09 97.65,40.61 97.65,40.71 U33.R7 ; U7.BB5 81.93,61.94 v1(82.16,61.69)
M_B_A12: length 66
  TOP w0.089: U26.N7 82.49,42.24 82.36,42.24 81.9,42.7 81.77,42.7 81.36,42.28 v3(81,42.28) ; v3(98.62,42.13) 98.84,42.35 98.94,42.35 99.1,42.51 99.44,42.51 99.66,42.29 99.66,42.09 99.75,42 99.99,42 100.09,42.1 100.09,42.32 100.33,42.57 U27.N7
  IN1 w0.089: v1(81.47,59.74) 81.47,59.43 81.6,59.3 81.81,59.3 81.88,59.37 81.88,59.56 81.97,59.65 82.11,59.65 82.19,59.57 82.19,59.36 82.25,59.3 82.81,59.3 82.87,59.36 82.87,59.47 82.95,59.55 83.1,59.55 83.18,59.47 83.18,59.38 83.25,59.3 83.56,59.3 83.64,59.38 83.64,59.87 83.72,59.94 83.85,59.94 83.95,59.85 83.95,59.41 84.02,59.34 84.17,59.34 84.25,59.43 84.25,59.66 84.33,59.74 84.47,59.74 84.56,59.65 84.56,59.5 84.63,59.42 84.85,59.42
  IN1 w0.135: v1(92.6,42.26) 92.86,42.52 92.86,43.16 92.61,43.41 92.61,43.99 92.72,44.1 92.72,45.93 92.72,47.17 92.38,47.52 92.38,47.88 92.91,48.41 92.91,49.92 92.63,50.2 92.63,52.04 92.48,52.19 89.25,55.43 88.52,55.43 88.13,55.82 87.87,55.82 87.6,55.54 87.34,55.54 87.31,55.58 86.86,55.58 86.27,56.17 86.27,56.85 86.15,56.97 85.72,56.97 85.48,57.21 85.48,58.79 84.85,59.42
  IN2 w0.102: v3(98.62,42.13) 98.42,41.93 98.02,41.93 97.91,42.03 97.91,42.2 97.81,42.31 97.53,42.31 97.42,42.19 97.42,41.83 97.29,41.71 97.13,41.71 97.01,41.82 97.01,42.08 96.91,42.18 96.71,42.18 96.61,42.08 96.61,41.85 96.51,41.74 96.3,41.74 96.2,41.85 96.2,42.08 96.1,42.18 95.9,42.18 95.79,42.08 95.79,41.3 95.66,41.16 95.49,41.16 95.39,41.26 95.39,41.91 95.29,42.01 95.09,42.01 94.98,41.9 94.98,41.77 94.86,41.65 94.69,41.65 94.58,41.77 94.58,42.08 94.47,42.18 94.32,42.18 94.22,42.08 94.22,41.71 94.08,41.57 93.92,41.57 93.81,41.67 93.81,42.08 93.71,42.18 93.51,42.18 93.41,42.08 93.41,41.49 93.31,41.39 93.11,41.39 93,41.5 93,42.08 92.9,42.18 92.67,42.18 v1(92.6,42.26) 91.78,42.26 91.58,42.05 90.16,42.05 89.96,41.85 89.26,41.85 89.15,41.75 86.87,41.75 86.43,42.18 86.14,42.18 86,42.33 85.62,42.33 85.48,42.18 83.58,42.18 83.22,42.54 81.61,42.54 81.6,42.53 81.6,42.53 81.35,42.28 v3(81,42.28)
  BOTTOM w0.089: U34.N7 79.62,42.92 79.71,43.01 79.92,43.01 80.03,42.91 80.03,42.43 80.18,42.28 v3(81,42.28) ; U7.BF6 81.48,59.9 v1(81.47,59.74) ; v3(98.62,42.13) 98.62,42.39 98.44,42.56 98.31,42.56 98.16,42.41 98.04,42.41 97.91,42.54 97.91,42.67 98.06,42.81 98.06,42.96 97.97,43.05 97.52,43.05 97.4,42.93 97.4,42.57 U33.N7
  BOTTOM w0.117: R1087.2 91.69,42.28 92.57,42.28 v1(92.6,42.26)
M_B_A13: length 75.3
  TOP w0.089: v3(81.56,38.01) 81.41,37.86 81.27,37.86 81.08,37.67 80.77,37.67 80.58,37.86 80.1,37.86 79.52,38.44 79.52,40.07 U26.T3 ; v3(99.32,38.06) 98.95,37.69 98.53,37.69 97.4,38.82 97.4,40.17 U27.T3
  TOP w0.117: v1(89.81,37.54) 89.38,37.11 88.8,37.11 R1093.2
  IN1 w0.135: v1(89.81,37.54) 90.07,37.8 91.67,37.8 91.86,37.99 91.86,38.39 91.69,38.56 91.19,38.56 91,38.75 91,39.32 91.47,39.79 91.47,40.12 91.29,40.3 90.71,40.3 90.53,40.47 90.53,40.83 90.71,41.01 91.1,41.01 91.27,41.18 91.27,41.59 90.27,42.6 90.27,44.43 91.07,45.23 91.07,45.24 91.07,46.49 90.73,46.83 90.73,49.23 87.26,52.7 87.26,53.44 v1(87.03,53.66)
  IN2 w0.102: v3(99.32,38.06) 98.92,37.66 98.45,37.66 97.32,36.53 94.12,36.53 93.76,36.88 93.76,37.21 93.23,37.74 92.86,37.74 92.56,37.44 92.09,37.44 91.88,37.65 90.6,37.65 90.49,37.54 v1(89.81,37.54) 86.4,37.54 85.88,38.06 84.61,38.06 84.51,37.96 84.51,37.63 84.4,37.53 84.2,37.53 84.1,37.63 84.1,37.96 84,38.06 83.8,38.06 83.69,37.96 83.69,37.63 83.59,37.53 83.39,37.53 83.29,37.63 83.29,37.96 83.19,38.06 82.98,38.06 82.88,37.96 82.88,37.63 82.78,37.53 82.58,37.53 82.47,37.63 82.47,37.96 82.37,38.06 81.99,38.06 81.94,38.01 v3(81.56,38.01)
  BOTTOM w0.089: v3(81.56,38.01) 81.27,38.3 81.27,38.42 81.35,38.5 82.06,38.5 82.21,38.65 82.33,38.65 82.41,38.58 82.62,38.58 82.79,38.75 82.79,38.89 82.7,38.98 82.55,38.98 82.46,39.07 82.46,39.25 82.55,39.34 82.73,39.34 82.82,39.42 82.82,40.17 U34.T3 ; U33.T3 100.6,40.17 100.6,38.83 100.32,38.55 100.32,38.53 100.15,38.36 100.15,38.31 100.05,38.2 99.92,38.2 99.62,38.51 99.18,38.51 99.09,38.42 99.09,38.15 99.18,38.06 v3(99.32,38.06) ; U7.BF10 79.71,59.54 79.37,59.21 79.37,58.93 79.46,58.84 79.46,58.36 79.62,58.2 79.62,56.65 81.41,54.85
  BOTTOM w0.102: 81.41,54.85 82.61,53.66 v1(87.03,53.66)
M_B_A14: length 71.8
  TOP w0.089: v3(80.93,38.05) 81.2,38.32 81.2,38.32 81.39,38.5 81.9,38.5 81.91,38.51 81.91,38.52 82.82,39.43 82.82,40.17 U26.T7 ; v1(81.54,60.9) 81.54,60.25 81.92,59.87 81.92,59.69 ; U27.T7 100.6,39.49 100.4,39.29 100.4,39 100.15,38.74 99.93,38.74 99.7,38.51 99.69,38.51 99.68,38.5 99.15,38.5 v3(98.72,38.06)
  TOP w0.117: 81.92,59.69 82.49,59.12 84.67,59.12 85.1,58.69 85.1,57.72 85.46,57.37 87.8,57.37 88.39,56.77 88.39,56.02 88.83,55.58 89.75,55.58 92.04,53.28 92.04,45.5 92.29,45.26 92.29,43.42 93.04,42.67 93.04,41.71 92.91,41.58 92.48,41.58 92.35,41.45 92.35,41.2 92.48,41.07 92.91,41.07 93.04,40.95 93.04,40.59 93.18,40.45 93.18,39.38 92.37,38.57 v1(92.37,37.89) 92.37,36.68 92.25,36.56 92.25,36.02 R1092.2
  IN2 w0.102: v3(80.93,38.05) 81.27,38.39 82.54,38.39 82.63,38.31 86,38.31 86.37,37.94 89.61,37.94 89.63,37.96 90.1,37.96 90.18,37.89 v1(92.37,37.89) 92.47,37.99 93.27,37.99 93.48,37.78 93.91,37.78 94.01,37.68 94.01,36.92 94.15,36.78 94.77,36.78 94.87,36.88 94.87,37.33 95.01,37.47 95.15,37.47 95.26,37.37 95.26,36.84 95.36,36.74 95.56,36.74 95.66,36.84 95.66,37.37 95.76,37.47 95.97,37.47 96.07,37.37 96.07,36.84 96.17,36.74 96.37,36.74 96.48,36.84 96.48,37.37 96.58,37.47 96.78,37.47 96.88,37.37 96.88,36.84 96.99,36.74 97.19,36.74 97.29,36.84 97.29,37.37 97.39,37.47 97.77,37.47 98.36,38.06 v3(98.72,38.06)
  BOTTOM w0.089: U34.T7 79.37,39.92 79.37,39.49 79.54,39.32 79.54,39.31 79.59,39.26 79.59,39.03 79.85,38.77 80.42,38.77 80.93,38.26 v3(80.93,38.05) ; v3(98.72,38.06) 98.72,38.3 98.11,38.91 97.96,38.91 97.82,38.77 97.66,38.77 97.58,38.85 97.58,39.03 97.71,39.16 97.71,39.31 97.4,39.62 97.4,40.17 U33.T7 ; v1(81.54,60.9) U7.BD7
M_B_A15: length 66.4
  TOP w0.089: v3(81.97,43.6) 81.96,43.58 81.96,43.19 82.15,43 83.08,43 83.17,43.09 83.17,43.28 83.08,43.37 U26.M7 ; v3(99.28,43.18) 99.3,43.19 99.78,43.19 99.85,43.13 100.11,43.13 100.29,42.94 100.67,42.94 100.78,43.06 100.78,43.18 U27.M7
  IN1 w0.089: 85.92,58.94 85.92,58.97 85.13,59.75 84.71,59.75 84.55,59.92 84.22,59.92 84.11,60.02 84.11,60.14 84.39,60.42 84.39,60.57 84.3,60.66 84.16,60.66 83.23,59.74 83.08,59.74 82.99,59.82 82.99,59.93 84.01,60.94 84.01,61.05 83.9,61.16 83.79,61.16 82.81,60.18 82.7,60.18 82.6,60.28 82.6,60.4 82.95,60.75 82.95,60.86 82.86,60.95 82.86,61.1 82.94,61.19 83.05,61.19 83.14,61.1 83.3,61.1 83.55,61.35 83.55,61.55 83.41,61.69 v1(83.1,61.69)
  IN1 w0.135: 85.92,58.94 85.92,57.61 86.22,57.3 86.52,57.3 86.81,57.02 86.81,56.76 86.6,56.56 86.6,56.3 86.99,55.91 87.39,55.91 87.82,56.34 88.07,56.34 88.65,55.76 89.39,55.76 92.96,52.18 92.96,50.33 93.28,50.01 93.28,48.27 93.28,47.34 93.05,47.1 93.05,46.06 v1(93.05,43.8)
  IN2 w0.102: v3(81.97,43.6) 81.97,43.63 82.05,43.71 82.19,43.71 82.49,43.41 88.55,43.41 88.91,43.06 89.85,43.06 89.97,42.93 91.28,42.93 91.4,43.06 92.02,43.06 92.77,43.8 v1(93.05,43.8) 93.31,43.54 93.31,42.93 93.44,42.8 93.94,42.8 94.04,42.9 94.04,43.24 94.18,43.37 96.34,43.37 96.57,43.14 98.32,43.14 98.82,43.64 99.62,43.64 99.96,43.98 100.82,43.98 100.93,43.86 100.93,43.28 100.78,43.13 99.81,43.13 99.76,43.18 v3(99.28,43.18)
  BOTTOM w0.089: v3(99.28,43.18) 99.17,43.29 98.51,43.29 98.46,43.24 97.52,43.24 U33.M7 ; v1(83.1,61.69) 83.1,61.37 83.01,61.28 82.05,61.28 U7.BD5 ; U34.M7 79.71,43.45 81.13,43.45 81.13,43.46 81.33,43.46 81.53,43.65 81.89,43.65 81.94,43.61 81.96,43.61 v3(81.97,43.6)
  BOTTOM w0.117: v1(93.05,43.8) 92.56,43.8 92.48,43.88 R1088.2
M_B_BS0: length 71.8
  TOP w0.089: U27.M2 96.96,43 97.74,43 98.2,42.54 98.8,42.54 98.8,42.54 98.83,42.54 99.09,42.8 99.53,42.8 99.6,42.74 99.8,42.74 99.87,42.67 v3(99.89,42.67) ; U26.M2 78.82,43.16 78.91,43.07 79,43.07 79.09,42.98 79.09,42.8 79.18,42.71 79.31,42.71 79.45,42.85 79.45,42.97 79.52,43.04 79.75,43.04 79.77,43.06 79.95,43.06 80.04,42.97 80.04,42.57 80.17,42.44 80.51,42.44 80.87,42.8 81.19,42.8 v3(81.22,42.83)
  TOP w0.117: R1090.2 88.79,42.12 88.79,42.28 v1(88.8,42.3)
  IN1 w0.135: v1(80.84,57.33) 80.84,57.03 84.22,53.65 84.85,53.65 85.02,53.48 85.02,53.48 85.8,52.71 85.8,52.29 89.36,48.73 89.36,47.34 88.85,46.83 88.85,45.74 88.5,45.38 88.5,44.99 87.67,44.17 87.67,37.34 87.85,37.16 88.28,37.16 88.45,37.33 88.45,41.94 v1(88.8,42.3)
  IN2 w0.102: v3(81.22,42.83) 81.25,42.8 83.25,42.8 83.65,42.4 85.09,42.4 85.63,42.94 86.72,42.94 86.83,42.84 86.83,42.14 86.91,42.06 87.17,42.06 87.27,42.16 87.27,42.84 87.37,42.94 87.58,42.94 87.68,42.84 87.68,42.05 87.79,41.95 87.97,41.95 88.13,42.11 88.13,42.84 88.23,42.94 88.41,42.94 88.58,42.77 88.58,42.51 v1(88.8,42.3) 89.02,42.07 89.9,42.07 90.08,42.25 91.4,42.25 91.7,42.56 92.18,42.56 92.28,42.66 92.76,42.66 92.77,42.65 92.78,42.65 93.05,42.38 94.61,42.38 94.75,42.25 95.57,42.25 95.7,42.38 96.71,42.38 96.83,42.51 98.86,42.51 99.12,42.77 99.45,42.77 99.56,42.67 v3(99.89,42.67)
  BOTTOM w0.089: U33.M2 101.79,43.37 101.88,43.45 101.88,43.73 101.79,43.82 101.16,43.82 100.93,43.59 100.93,43.25 100.92,43.24 100.92,43.23 100.76,43.07 100.76,42.97 100.68,42.89 100.11,42.89 v3(99.89,42.67) ; v3(81.22,42.83) 81.25,42.85 81.98,42.85 82.17,43.04 83.02,43.04 83.15,43.17 83.15,43.66 83.23,43.75 83.53,43.75 83.62,43.66 U34.M2 ; U7.BH8 80.44,59.06 80.44,57.72 v1(80.84,57.33)
M_B_BS1: length 78.5
  TOP w0.089: U27.N8 101.4,42.29 101.26,42.16 100.49,42.16 100.09,41.76 99.07,41.76 98.65,41.34 v3(98.65,41.33) ; 76.95,57.48 77.12,57.65 77.52,57.65 77.63,57.76 77.63,59.08 77.55,59.17 77.1,59.17 77.02,59.24 77.02,59.39 77.1,59.47 77.55,59.47 77.63,59.55 77.63,60.14 77.58,60.18 77.58,61.89 77.63,61.94 77.63,63.1 77.71,63.18 77.85,63.18 v1(78.22,62.81) ; v3(80.94,41.46) 81.07,41.46 81.37,41.76 81.95,41.76 82.14,41.95 82.26,41.95 82.34,41.87 82.46,41.87 82.75,42.16 83.43,42.16 83.62,42.34 U26.N8
  TOP w0.117: R1100.2 89.74,40.18 89.74,40.38 89.73,40.39 89.73,40.54 89.62,40.65 v1(89.62,41.16) 89.36,41.43 89.36,41.61 89.48,41.74 89.83,41.74 89.96,41.87 89.96,42.17 90.18,42.4 90.18,42.53 90.35,42.69 90.35,42.87 89.99,43.23 89.99,43.96 89.68,44.27 89.68,44.45 90.18,44.95 90.18,45.15 88.51,46.81 88.51,50.97 88.74,51.21 89.88,51.21 90.01,51.33 90.01,51.59 89.82,51.77 89.09,51.77 88.93,51.94 88.93,52.69 88.5,53.11 88.35,53.11 86.87,54.6 86.71,54.6 86.55,54.76 86.29,54.76 85.94,54.41 85.73,54.41 85.21,53.9 84.77,53.9 84.42,54.24 84.42,54.54 84.2,54.76 83.32,54.76 82.67,55.41 81.98,55.41 81.59,55.8 81.59,56.15 81.45,56.3 80.29,56.3 79.59,57 77.21,57 76.95,57.26 76.95,57.48
  IN2 w0.102: v3(80.94,41.46) 81.24,41.77 81.74,41.77 81.88,41.63 82.42,41.63 82.52,41.74 82.52,41.85 82.63,41.96 82.83,41.96 82.93,41.85 82.93,41.74 83.03,41.63 83.47,41.63 83.94,41.17 84.17,41.17 84.74,41.73 85.27,41.73 85.37,41.63 85.37,41.35 85.26,41.23 85.26,40.91 85.36,40.81 86.67,40.81 86.68,40.82 86.71,40.82 87.12,41.24 87.25,41.24 87.47,41.02 87.61,41.02 87.71,41.12 87.71,41.23 87.82,41.33 88.02,41.33 88.12,41.23 88.12,41.12 88.22,41.02 88.43,41.02 88.53,41.12 88.53,41.23 88.63,41.33 88.83,41.33 88.93,41.23 88.93,41.12 89.04,41.02 89.48,41.02 v1(89.62,41.16) 89.65,41.19 89.98,41.19 90.22,41.43 90.37,41.43 90.61,41.19 90.74,41.19 90.84,41.29 90.84,41.51 90.95,41.61 91.15,41.61 91.25,41.51 91.25,41.29 91.35,41.19 91.52,41.19 91.71,41.38 91.72,41.38 91.73,41.4 92.51,41.4 93.59,40.33 93.84,40.33 93.94,40.43 93.94,40.6 94.04,40.7 94.75,40.7 94.87,40.83 95.17,40.83 95.25,40.75 95.5,40.75 95.58,40.67 95.58,40.3 95.69,40.19 96.37,40.19 96.63,40.46 96.63,40.9 97.02,41.29 97.59,41.29 97.82,41.52 98.47,41.52 v3(98.65,41.33)
  BOTTOM w0.089: U7.AY14 v1(78.22,62.81) ; v3(80.94,41.46) 80.46,41.46 80.44,41.45 80.23,41.45 79.95,41.73 79.95,41.95 79.78,42.12 78.65,42.12 78.52,42.24 78.52,42.47 78.62,42.57 78.82,42.57 U34.N8 ; v3(98.65,41.33) 98.36,41.62 98.36,41.82 97.96,42.23 97.34,42.23 97.08,41.98 96.86,41.98 96.73,42.11 96.43,42.11 96.36,42.18 96.36,42.33 U33.N8
M_B_BS2: length 65
  TOP w0.089: v3(80.41,43.02) 80.64,43.02 80.81,43.19 81.02,43.19 81.11,43.28 81.11,43.41 81.02,43.5 80.9,43.5 80.83,43.42 80.24,43.42 80.19,43.37 U26.M3 ; U27.M3 97.5,43.26 98.08,43.26 98.25,43.43 98.81,43.43 98.9,43.34 98.9,43.17 v3(98.64,42.92)
  TOP w0.117: v1(89.68,42.48) 89.67,42.48 88.85,41.66 88.85,40.3 R1097.2
  IN1 w0.135: v1(84.65,57.9) 84.28,57.9 84.1,57.72 84.1,57.18 83.34,56.42 83.34,55.96 84.67,54.64 85.33,54.64 86.27,53.7 86.29,53.7 86.9,53.09 86.9,52.59 90.4,49.09 90.4,46.7 90.74,46.35 90.74,45.37 89.57,44.2 89.35,44.2 89.17,44.02 88.8,44.02 88.8,44.02 88.54,43.76 88.54,43.76 88.51,43.73 88.51,43.37 88.75,43.13 89.8,43.13 89.94,42.98 89.94,42.75 v1(89.68,42.48)
  IN2 w0.102: v3(80.41,43.02) 80.6,43.21 81.06,43.21 81.06,43.21 81.38,43.21 81.54,43.05 83.29,43.05 83.73,42.6 85.01,42.6 85.55,43.14 88.53,43.14 88.83,42.85 89.31,42.85 v1(89.68,42.48) 91.28,42.48 91.61,42.81 92.06,42.81 92.64,43.38 92.95,43.38 93.11,43.22 93.11,42.75 93.27,42.58 94.7,42.58 94.8,42.48 95.45,42.48 95.56,42.58 96.38,42.58 96.71,42.92 v3(98.64,42.92)
  BOTTOM w0.089: v3(98.64,42.92) 99.01,42.92 99.13,42.8 99.44,42.8 99.78,43.14 100.38,43.14 U33.M3 ; v3(80.41,43.02) 80.59,43.2 80.85,43.2 80.85,43.2 81.07,43.2 82.06,43.2 82.1,43.24 82.51,43.24 82.63,43.37 U34.M3 ; v1(84.65,57.9) 84.84,57.7 86.35,57.7 86.44,57.79 86.44,57.95 86.32,58.07 85.19,58.07 85.12,58.14 85.12,58.37 85.17,58.43 86.64,58.43 86.73,58.51 86.73,58.68 86.62,58.78 84.95,58.78 84.65,59.09 84.65,59.81 84.34,60.11 83.88,60.11 U7.BF2
M_B_CAS#: length 58.9
  TOP w0.089: U26.K3 79.62,44.81 79.71,44.72 79.87,44.72 79.95,44.81 79.95,45.17 79.79,45.33 79.79,45.47 79.88,45.55 80.03,45.55 80.13,45.45 80.42,45.45 80.62,45.64 v3(80.89,45.64) ; v3(98.62,45.13) 98.62,45.54 98.53,45.63 97.88,45.63 97.83,45.58 97.67,45.58 97.4,45.31 U27.K3
  TOP w0.117: R1094.2 88.66,45.63 88.38,45.91 v1(88.38,45.95)
  IN1 w0.135: v1(88.38,45.95) 88.39,45.95 88.52,46.08 88.52,46.97 89.03,47.48 89.03,47.74 88.75,48.01 88.75,48.26 88.95,48.45 88.95,48.68 88.6,49.03 88.34,49.03 88.04,48.73 87.81,48.73 87.48,49.05 87.48,49.3 87.75,49.57 87.75,49.86 87.57,50.04 86.75,50.04 86.49,50.3 86.49,51.13 86.16,51.46 85.63,51.46 85.4,51.7 85.4,52.65 84.96,53.08 84.71,53.08 84.38,52.74 84.08,52.74 83.95,52.88 83.95,53.45 83.63,53.77 83.37,53.77 83.19,53.59 82.94,53.59 82.69,53.84 82.69,54.09 82.87,54.28 82.87,54.53 82.64,54.76 v1(82.47,54.76)
  IN2 w0.089: v1(88.38,45.95) 88.75,45.95 88.93,45.77 89.21,45.77 89.34,45.9 89.34,46.09 89.42,46.17 89.67,46.17 89.81,46.04 89.81,45.83 89.99,45.64 94.03,45.64 94.27,45.87 94.77,45.87 94.92,45.72 95,45.72 95.98,44.74 97.17,44.74 97.55,45.13 v3(98.62,45.13)
  IN2 w0.102: v3(80.89,45.64) 80.89,45.49 81,45.38 81.3,45.38 82.37,45.38 82.99,44.75 84.37,44.75 84.63,45.02 84.63,45.27 84.75,45.39 86.25,45.39 86.32,45.33 86.32,45.19 86.41,45.1 86.64,45.1 86.75,45.21 86.75,45.75 86.85,45.84 87.08,45.84 87.18,45.74 87.18,44.83 87.28,44.73 87.69,44.73 87.76,44.8 87.76,44.95 87.59,45.12 87.59,45.44 87.61,45.46 87.61,45.54 87.72,45.65 87.8,45.65 87.82,45.66 88.28,45.66 88.38,45.76 v1(88.38,45.95)
  BOTTOM w0.089: v1(82.47,54.76) 82.32,54.76 82.07,55.01 82.07,55.14 82.46,55.52 82.46,55.65 82.34,55.77 82.2,55.77 81.77,55.34 81.65,55.34 81.53,55.46 81.53,55.6 81.93,56 81.93,56.16 81.82,56.26 81.69,56.26 81.27,55.84 81.14,55.84 81.02,55.96 81.02,56.1 81.36,56.44 81.36,56.56 81.24,56.68 81.1,56.68 80.83,56.41 80.69,56.41 80.55,56.55 80.55,56.78 80.43,56.9 80.26,56.9 80.13,56.9 80.05,56.99 80.05,58.3 80.01,58.34 80.01,58.36 79.85,58.52 79.85,58.84 80.1,59.09 U7.BG9 ; U34.K3 82.82,45.18 82.68,45.32 82.49,45.32 82.35,45.46 82,45.46 81.87,45.32 80.98,45.32 80.89,45.41 v3(80.89,45.64) ; v3(98.62,45.13) 98.65,45.09 99.25,45.09 99.38,44.97 99.48,44.97 99.66,44.79 100.02,44.79 100.2,44.97 100.6,44.97 U33.K3
M_B_CKE0: length 73.5
  TOP w0.089: v3(80.33,45.07) 80.51,45.07 80.67,45.23 82.04,45.23 82.71,44.57 83.43,44.57 83.44,44.56 84.01,44.56 U26.K9
  TOP w0.102: v3(99.82,45.17) 99.59,45.17 99.48,45.05 99.48,44.76 99.98,44.27 100.12,44.27 100.22,44.37 100.22,44.51 100.32,44.61 100.7,44.61 100.89,44.41 101.07,44.41 101.2,44.55 101.56,44.55 101.75,44.35 101.9,44.35 102.2,44.65 U27.K9
  IN1 w0.089: v1(80.09,62.69) 79.81,62.97 78.75,62.97 78.62,62.84 78.62,62.6 78.72,62.5 79.43,62.5 79.74,62.19 80.11,62.19 80.2,62.1 80.2,61.97 79.8,61.58 79.8,59.82 80.07,59.55 80.69,59.55 81.99,58.25 81.99,56.87 82.18,56.68 82.35,56.68 82.47,56.8 82.47,57.59 82.58,57.7 82.87,57.7 82.99,57.58 82.99,57.35
  IN1 w0.135: v1(89.62,45.02) 89.45,45.2 89.45,45.4 89.71,45.67 90.22,45.67 90.41,45.86 90.41,46.22 90.07,46.56 90.07,48.95 86.46,52.56 86.46,52.98 85.3,54.15 85.29,54.15 85.13,54.31 84.49,54.31 82.99,55.81 82.99,57.35
  IN2 w0.102: v3(80.33,45.07) 80.2,45.07 79.8,44.67 79.8,44.48 79.91,44.38 80.13,44.38 80.38,44.63 80.59,44.63 80.76,44.45 81.11,44.45 81.33,44.67 81.33,44.73 81.55,44.96 81.87,44.96 81.91,44.91 82.27,44.91 82.88,44.3 88.4,44.3 88.74,44.63 88.74,45.13 88.88,45.27 89.07,45.27 89.32,45.02 v1(89.62,45.02) 94.05,45.02 94.32,44.76 95.41,44.76 95.82,44.35 97.16,44.35 97.33,44.35 97.53,44.55 98.67,44.55 98.89,44.34 99.21,44.34 99.22,44.35 99.33,44.47 99.69,44.47 99.86,44.29 100.27,44.29 100.37,44.4 100.37,44.59 v3(99.82,45.17)
  BOTTOM w0.089: v3(80.33,45.07) 80.52,44.88 80.52,44.68 80.45,44.6 80.24,44.6 80,44.36 79.88,44.36 79.72,44.52 79.47,44.52 79.3,44.69 79.11,44.69 78.94,44.52 78.72,44.52 78.55,44.69 78.36,44.69 78.19,44.52 77.87,44.52 77.86,44.52 77.72,44.52 77.54,44.69 77.54,44.87 77.64,44.97 U34.K9 ; v1(80.09,62.69) U7.BB10
  BOTTOM w0.102: v3(99.82,45.17) 99.5,45.17 99.37,45.29 99.09,45.29 98.85,45.53 98.45,45.53 97.75,44.84 97.75,44.82 97.53,44.59 96.15,44.59 96.05,44.7 96.05,44.72 U33.K9
  BOTTOM w0.117: v1(89.62,45.02) 89.62,45.33 89.63,45.34 R1103.2
M_B_CLKN0: length 71.5
  TOP w0.089: v3(98.97,46.3) 99.06,46.39 99.18,46.39 99.48,46.1 99.94,46.1 100.04,46 100.04,45.54 100.37,45.2 100.51,45.2 100.6,45.11 ; U26.K7 82.82,45.18 82.73,45.27 82.49,45.27 81.83,45.93 81.83,46.7 81.59,46.94 81.47,46.94 v3(81.27,46.75)
  TOP w0.094: U27.K7 100.6,45.11 100.6,45.11
  IN1 w0.089: 79.61,58.72 79.57,58.76 79.57,58.76 79.34,58.99 78.5,58.99 77.81,59.69 77.81,60.24 77.96,60.39 78.62,60.39 78.74,60.28 78.74,60.05 78.66,59.97 78.24,59.97 v1(78.22,59.99)
  IN1 w0.14: 79.61,58.72 80.01,58.33 80.01,57.16 81.91,55.26 81.91,53.79 84.28,51.42 84.76,51.42 85.77,50.41 85.77,50.08 86.61,49.24 86.61,47.09 85.59,46.06 85.59,44.99 85.16,44.56 84.5,44.56 84.33,44.39 84.33,44.1 84.47,43.96 85.78,43.96 86.43,44.61 86.43,45.43 87.71,46.71 87.71,47.68 87.57,47.82 87.34,47.82 87.21,47.69 v1(87.21,47.37)
  IN2 w0.102: v3(98.97,46.3) 98.97,46.48 98.74,46.71 98.6,46.71 98.21,46.32 96.7,46.32 95.88,47.14 95.08,47.14 94.89,47.34 94.07,47.34 93.83,47.09 90.7,47.09 89.99,47.81 87.65,47.81 v1(87.21,47.37) 86.78,47.8 86.6,47.8 86.39,48 86.39,48.82 86.74,49.17 87.16,49.17 87.29,49.31 87.29,49.65 87.13,49.81 85.7,49.81 85.7,49.81 85.7,49.79 85.51,49.61 85.51,49.04 85.45,48.97 85.45,47.64 85.61,47.48 85.61,46.83 85.11,46.34 82.85,46.34 82.69,46.5 81.97,46.5 81.57,46.9 81.42,46.9 v3(81.27,46.75)
  BOTTOM w0.076: U7.BF14 78.2,59.99 v1(78.22,59.99)
  BOTTOM w0.089: v3(81.27,46.75) 81.13,46.88 81,46.88 80.92,46.79 80.92,46.2 79.99,45.28 79.72,45.28 79.62,45.18 U34.K7 ; U33.K7 97.4,44.97 97.4,45.22 97.51,45.33 97.7,45.33 98.15,45.77 98.15,46.02 98.71,46.58 98.88,46.58 98.97,46.49 v3(98.97,46.3)
  BOTTOM w0.127: v1(87.21,47.37) 87.57,47.73 88.3,47.73 C794.1 88.59,47.44 89.09,47.44 R1106.2
M_B_CLKP0: length 71.6
  TOP w0.089: v3(99.3,46.79) 99.26,46.75 99.26,46.6 99.57,46.3 100.02,46.3 100.24,46.09 100.24,45.62 100.46,45.4 100.53,45.4 100.6,45.47 U27.J7 ; U26.J7 82.82,45.77 82.82,45.56 82.73,45.47 82.58,45.47 82.04,46.01 82.04,46.78 81.67,47.15 81.42,47.15 v3(81.24,47.33)
  IN1 w0.089: 79.45,58.56 79.44,58.57 79.44,58.6 79.41,58.64 79.41,58.67 79.27,58.82 78.43,58.82 77.63,59.62 77.63,60.31 77.89,60.57 77.97,60.57 v1(78.19,60.79)
  IN1 w0.14: v1(87.21,48.31) 87.44,48.09 87.68,48.09 87.98,47.79 87.98,46.6 86.7,45.32 86.7,44.5 85.89,43.69 84.36,43.69 84.06,43.99 84.06,44.5 84.39,44.83 85.05,44.83 85.32,45.1 85.32,46.17 86.35,47.2 86.35,49.13 85.5,49.97 85.5,50.3 84.65,51.15 84.17,51.15 81.64,53.68 81.64,55.15 79.74,57.05 79.74,58.27 79.74,58.27 79.45,58.56
  IN2 w0.102: v3(81.24,47.33) 81.44,47.13 81.66,47.13 82.06,46.73 82.78,46.73 82.94,46.56 85.02,46.56 85.38,46.92 85.38,47.38 85.22,47.54 85.22,49.07 85.28,49.13 85.28,49.7 85.61,50.03 87.22,50.03 87.51,49.74 87.51,49.22 87.25,48.96 86.83,48.96 86.61,48.73 86.61,48.09 86.68,48.01 86.92,48.01 v1(87.21,48.31) 87.5,48.03 90.08,48.03 90.79,47.31 93.74,47.31 93.98,47.56 94.98,47.56 95.17,47.36 95.97,47.36 96.79,46.54 98.12,46.54 98.51,46.93 98.83,46.93 98.97,46.79 v3(99.3,46.79)
  BOTTOM w0.076: v1(78.19,60.79) 78.15,60.75 77.91,60.75 77.76,60.9 U7.BD14
  BOTTOM w0.089: U33.J7 97.4,45.62 97.49,45.53 97.62,45.53 97.94,45.86 97.94,46.1 98.63,46.79 v3(99.3,46.79) ; v3(81.24,47.33) 81.01,47.11 80.94,47.11 80.71,46.88 80.71,46.29 79.9,45.48 79.72,45.48 79.62,45.58 U34.J7
  BOTTOM w0.127: R1105.2 89.04,48.3 C794.2 88.17,47.97 87.56,47.97 v1(87.21,48.31)
M_B_CLKP0_N0_C: length 1.8
  BOTTOM w0.108: C793.2 90.22,48.7 R1105.1 R1106.1
M_B_CS#0: length 82.1
  TOP w0.089: v1(77.23,63.53) 76.73,63.53 76.65,63.44 76.65,63.28 76.79,63.13 76.79,62.98 76.64,62.83 76.64,62.68 76.83,62.49 76.83,62.31 76.65,62.14 76.65,61.99 76.84,61.8 76.84,61.64 76.64,61.44 76.64,61.28 76.85,61.08 76.85,60.91 76.64,60.7 76.64,60.53 76.86,60.31 76.86,60.19 76.68,60.02 76.68,59.86 76.79,59.75 76.79,58.93 76.87,58.86 77.37,58.86 77.44,58.78 77.44,58.63 77.37,58.55 76.56,58.55 76.47,58.64 76.47,59.49 76.4,59.56 76.23,59.56 76.14,59.47 76.14,58.61 76.08,58.55 75.72,58.55 75.64,58.47 75.64,58.3 75.71,58.23 75.71,57.96 75.48,57.73 75.48,57.6 75.57,57.51 76.01,57.51 76.1,57.6 76.1,58.12 ; U27.L2 96.35,44.41 96.19,44.41 96.12,44.34 96.12,44.03 95.92,43.83 95.92,43.72 96.15,43.49 96.26,43.49 96.48,43.7 96.72,43.7 96.96,43.46 97.02,43.46 97.22,43.67 97.22,43.75 97.32,43.84 97.54,43.84 97.59,43.79 97.72,43.79 v3(97.88,43.63) ; v3(81.19,43.87) 81.01,43.69 80.82,43.69 80.75,43.61 79.97,43.61 79.74,43.84 79.38,43.84 79.23,43.69 78.35,43.69 78.26,43.78 78.26,43.95 78.48,44.17 78.82,44.17 U26.L2
  TOP w0.117: v1(88.98,43.58) 88.96,43.59 88.96,43.91 89.36,44.31 89.36,44.7 89.21,44.85 89.21,45.2 89.36,45.35 89.36,45.57 88.23,46.7 88.23,51.2 88.65,51.62 88.65,52.57 88.39,52.83 88.18,52.83 87.81,53.2 86.8,53.2 85.93,54.07 85.71,54.07 85.27,53.64 84.37,53.64 84.19,53.81 84.19,54.35 84.02,54.52 82.91,54.52 82.68,54.3 82.29,54.3 82.06,54.53 82.06,54.92 80.96,56.01 80.19,56.01 80.18,56.02 80.17,56.02 79.49,56.71 77.04,56.71 76.62,57.13 76.62,58.05 76.47,58.2 76.18,58.2 76.1,58.12
  IN2 w0.102: v3(81.19,43.87) 81.12,43.94 80.81,43.94 80.67,43.8 79.58,43.8 79.48,43.69 79.48,43.55 79.61,43.42 81.49,43.42 81.58,43.52 81.58,43.85 81.72,43.99 82.27,43.99 82.62,43.65 88.91,43.65 v1(88.98,43.58) 89.22,43.33 90.13,43.33 90.26,43.2 91.16,43.2 91.22,43.26 91.86,43.26 92.22,43.62 92.22,44.18 92.37,44.33 93.53,44.33 93.68,44.18 93.68,43.64 93.79,43.53 93.99,43.53 94.13,43.67 94.13,44.01 94.23,44.11 94.43,44.11 94.53,44.01 94.53,43.76 94.65,43.64 94.79,43.64 94.89,43.74 94.89,44.01 95,44.11 95.2,44.11 95.33,43.98 95.33,43.74 95.49,43.58 96.83,43.58 97.03,43.38 97.63,43.38 v3(97.88,43.63)
  BOTTOM w0.089: U34.L2 83.62,44.26 83.47,44.41 83.25,44.41 83.16,44.32 83.16,44 83,43.84 82.83,43.84 82.55,43.56 82.4,43.56 82.34,43.62 82.34,43.85 82.09,44.11 81.52,44.11 81.36,44.27 81.35,44.27 81.32,44.3 81.19,44.3 81.1,44.21 81.1,44.07 81.19,43.98 v3(81.19,43.87) ; U7.AY16 v1(77.23,63.53) ; U33.L2 101.4,44.17 101.09,44.17 100.76,43.84 100.37,43.84 100.26,43.96 99.94,43.96 99.62,43.63 98.9,43.63 98.83,43.57 97.94,43.57 v3(97.88,43.63)
  BOTTOM w0.117: R1082.2 88.37,42.97 v1(88.98,43.58)
M_B_DM0: length 32.6
  IN2 w0.094: v1(87.92,65.19) 87.92,64.54 88.52,63.94 88.75,63.94 88.89,64.09 88.89,64.42 89.01,64.54 89.21,64.54 89.32,64.43 89.32,63.97 89.43,63.86 89.63,63.86 89.73,63.96 89.73,64.43 89.83,64.54 90.03,64.54 90.14,64.43 90.14,63.97 90.25,63.86 90.44,63.86 90.54,63.96 90.54,64.43 90.64,64.54 90.84,64.54 90.95,64.43 90.95,63.97 91.09,63.82 ; 99.58,51.96 99.73,51.82 99.73,51.5 99.69,51.46 v3(99.69,51.19)
  IN2 w0.107: 99.58,51.96 99.58,55.58 98.91,56.25 98.91,57.79 97.3,59.4 97.22,59.4 94.61,59.4 94.32,59.69 94.32,60.61 93.48,61.44 93.48,62.97 92.64,63.82 91.09,63.82
  BOTTOM w0.089: U7.AP2 84.02,66.13 84.08,66.19 85.49,66.19
  BOTTOM w0.094: 85.49,66.19 85.56,66.19 86.24,65.51 87.61,65.51 v1(87.92,65.19) ; U33.D3 100.6,49.77 100.09,49.77 99.78,50.08 99.78,50.47 99.67,50.58 99.67,51.15 99.69,51.18 v3(99.69,51.19)
M_B_DM1: length 51.4
  IN1 w0.089: v1(82.22,64.67) 82.22,64.95 82.35,65.08 83.22,65.08 83.35,64.95 83.35,64.59 83.44,64.51 83.63,64.51 83.71,64.58 83.71,64.95 83.8,65.04 84.28,65.04 84.37,64.95 84.37,64.79 84.04,64.45 84.04,64.33 84.19,64.17 84.32,64.17 84.41,64.27 87.08,64.27 87.54,64.73 87.54,64.89 87.33,65.1 87.33,65.23 87.69,65.59 91.11,65.59 91.2,65.5 91.2,65.09 91.28,65.01 91.69,65.01 91.86,64.84 92.47,64.84 ; 103.18,46.53 100.69,46.53 100.47,46.75 100.47,47.05 100.01,47.51 99.83,47.51 99.55,47.24 99.12,47.24 98.64,47.72 98.64,48.17 98.77,48.3 v3(99,48.3)
  IN1 w0.107: 92.47,64.84 93.98,64.84 98.34,60.47 98.42,60.47 101.29,57.6 101.67,57.6 101.82,57.45 101.82,57.07 101.94,56.95 102.31,56.95 102.52,56.75 102.52,56.37 102.67,56.22 103.07,56.22 103.09,56.2 103.18,56.2 105.38,53.99 105.38,53.85 105.17,53.63 105.17,53.46 105.27,53.35 105.53,53.35 105.63,53.25 105.63,52.95 105.55,52.87 105.25,52.87 105.17,52.8 105.17,52.49 105.25,52.42 105.5,52.42 105.63,52.28 105.63,51.84 105.17,51.37 105.17,49.45 105.17,49.16 105.35,48.98 105.35,48.84 105.25,48.73 105.19,48.73 105.19,48.73 104.85,48.73 104.85,48.73 104.77,48.73 104.61,48.57 104.61,48.5 104.61,48.5 104.61,48.16 104.61,48.15 104.61,48.15 104.48,48.02 104.06,48.02 103.95,47.91 103.95,47.3 103.18,46.53
  BOTTOM w0.089: v1(82.22,64.67) U7.AT6
  BOTTOM w0.094: U33.E7 97.4,48.96 98.04,48.96 98.04,48.97 98.41,48.97 99,48.38 v3(99,48.3)
M_B_DM2: length 37.3
  TOP w0.094: v3(97.88,49.34) 98.17,49.64 100.1,49.64 100.34,49.4 100.34,49.22 U27.E7
  IN2 w0.089: v1(80.09,65.66) 80.09,65.37 80.19,65.26 83.34,65.26 ; 95.08,50.8 95.08,50.59 95.31,50.37 96.26,50.37 96.71,49.91 97.43,49.91 97.52,49.82 97.52,49.64 97.31,49.43 97.31,49.29 97.45,49.15 97.69,49.15 v3(97.88,49.34)
  IN2 w0.107: 83.34,65.26 84.14,64.45 84.14,63.99 84.51,63.61 84.77,63.61 85.11,63.95 85.31,63.95 85.47,63.79 85.47,63.58 85.12,63.23 85.12,63.09 85.26,62.95 85.41,62.95 85.84,63.37 85.98,63.37 86.12,63.23 86.12,63.09 85.7,62.66 85.7,62.51 85.84,62.37 85.98,62.37 86.41,62.8 86.55,62.8 86.7,62.65 86.7,62.51 86.27,62.08 86.27,61.94 86.41,61.8 86.56,61.8 86.78,62.02 86.93,62.02 87.03,61.91 87.03,59.48 92.29,54.22 92.29,53.83 92.88,53.23 93.04,53.23 93.09,53.28 93.24,53.28 93.39,53.13 93.39,52.98 93.34,52.93 93.34,52.78 93.5,52.61 93.84,52.61 94.26,53.03 94.48,53.03 94.62,52.89 94.62,52.44 95.12,51.94 95.12,51.73 94.89,51.49 94.89,51.25 95.08,51.06 95.08,50.8
  BOTTOM w0.094: U7.AP10 79.77,66.08 v1(80.09,65.66)
M_B_DM3: length 27.4
  TOP w0.094: U27.D3 97.44,49.77 98.31,50.63 98.31,50.8 99.01,51.51 99.2,51.51 v3(99.35,51.66)
  IN1 w0.089: v3(99.35,51.66) 99.59,51.9 99.59,51.99 99.59,51.99 99.59,54.59 98.21,55.97 98.2,55.97
  IN1 w0.107: 98.2,55.97 98.2,55.98 97.42,55.98 96.85,56.55 95.85,57.55 95.85,58.09 95.85,58.09 95.85,58.13 93.94,60.04 93.82,60.04 93.72,59.93 93.72,59.56 93.62,59.45 93.42,59.45 93.31,59.56 93.31,59.93 93.21,60.04 93.02,60.04 92.92,59.93 92.92,59.58 92.82,59.48 92.64,59.48 92.52,59.61 92.52,59.93 92.41,60.04 89.6,60.04 v1(89.19,59.63)
  BOTTOM w0.089: 85.1,62.25 84.62,62.73 U7.BA1
  BOTTOM w0.094: 85.1,62.25 87.05,62.25 88.09,61.21 88.09,60.74 v1(89.19,59.63)
M_B_DM4: length 12.2
  BOTTOM w0.089: U7.BG13 78.2,59.13 77.93,58.86 77.93,58.51 78,58.44 78,57.44
  BOTTOM w0.094: U34.D3 82.56,50.03 81.87,50.03 81.64,50.26 81.64,51.82 79.5,53.95 79.5,54.43 78.12,55.81 78.12,57.32 78,57.44
M_B_DM5: length 25.9
  TOP w0.094: v3(81.19,50.76) 81.58,50.76 81.7,50.64 81.7,49.13 81.86,48.97 82.82,48.97 U26.E7
  IN1 w0.107: v3(81.19,50.76) 81.19,50.92 80.44,51.67 80.44,51.7 80.43,51.71 80.43,51.96 79.71,52.68 79.58,52.68 79.07,52.18 78.92,52.18 78.78,52.32 78.78,52.46 79.29,52.97 79.29,53.12 79.14,53.26 79,53.26 78.49,52.75 78.35,52.75 78.06,53.04 78.06,53.61 78.06,53.92 77.82,54.16 77.82,54.3 78.09,54.56 78.09,54.71 77.94,54.85 77.8,54.85 77.54,54.59 77.4,54.59 76.86,55.12 76.86,55.45 76.96,55.55 77.69,55.55 77.81,55.66 77.81,55.85 77.7,55.95 76.96,55.95 76.86,56.05 76.86,56.26 76.96,56.36 77.66,56.36 77.76,56.46 77.76,56.61 77.61,56.77 76.96,56.77 76.86,56.87 76.86,57.48 76.43,57.91 76.43,58.64 75.61,59.47 75.61,62.82 75.79,63 76.06,63 v1(76.24,62.81)
  BOTTOM w0.089: U7.AY18 v1(76.24,62.81)
M_B_DM6: length 27.1
  IN2 w0.089: v1(73.34,60.68) 73.74,60.28 73.74,59.8 73.35,59.41 73.35,58.79 73.72,58.41
  IN2 w0.107: v3(80.2,50.61) 79.74,51.07 79.29,51.07 78.39,51.97 78.39,52.43 78.2,52.62 78.03,52.62 77.92,52.51 77.92,52.3 77.82,52.2 77.61,52.2 77.51,52.3 77.51,52.69 77.41,52.79 76.86,52.79 76.7,52.63 76.7,51.79 76.5,51.6 75.88,51.6 75.74,51.75 75.74,54.86 75.63,54.96 75.43,54.96 75.33,54.85 75.33,51.73 75.22,51.62 74.99,51.62 74.89,51.72 74.89,54.38 74.03,55.24 74.03,57.42 73.73,57.72 73.73,58.4 73.72,58.41
  BOTTOM w0.089: U7.BD22 v1(73.34,60.68)
  BOTTOM w0.094: U34.E7 79.62,49.28 80.2,49.86 v3(80.2,50.61)
M_B_DM7: length 15.7
  TOP w0.094: v1(73.47,55.28) 74.31,55.28 75.44,54.15 77.94,54.15 77.99,54.21 78.36,54.21 78.38,54.23 78.72,54.23 78.91,54.04 79.02,54.04 80.62,52.44 80.62,50.48 79.9,49.77 U26.D3
  BOTTOM w0.089: U7.BH24 72.86,57.73
  BOTTOM w0.094: 72.86,57.73 72.94,57.65 72.94,57.3 72.96,57.28 72.96,55.79 v1(73.47,55.28)
