# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQSP2: length 40.6
  TOP w0.089: v1(98.21,48.52) 98.21,48.45 97.96,48.2 97.93,48.2 97.62,47.89 97.47,47.89 97.4,47.96 U27.F3
  IN2 w0.089: 85.66,61.55 85.63,61.57 85.61,61.57 83.63,63.55 83.63,63.8 83.17,64.26 79.18,64.26 79.06,64.38 79.06,64.59 79.13,64.67 v1(79.37,64.67) ; 94.43,50.08 94.45,50.08 94.48,50.05 96.13,50.05 96.26,49.92 96.41,49.92 97.61,48.72 97.61,48.36 97.77,48.2 97.96,48.2 98.04,48.28 98.05,48.28 98.21,48.44 v1(98.21,48.52)
  IN2 w0.14: 85.66,61.55 85.76,61.44 85.77,61.44 86.38,60.84 86.38,57.41 86.73,57.05 86.73,56.62 86.38,56.27 86.38,55.92 87.33,54.96 87.53,54.96 87.85,55.27 88.32,55.27 88.62,54.98 88.62,54.48 88.11,53.97 88.11,53.76 88.67,53.2 88.98,53.2 89.72,53.94 90.16,53.94 90.5,53.6 90.5,53.18 90.13,52.81 90.13,52.56 90.3,52.39 90.51,52.39 91.34,53.22 91.79,53.22 92.13,52.89 92.13,52.47 91.35,51.69 91.35,51.49 91.54,51.29 91.74,51.29 92.48,52.03 92.94,52.03 93.27,51.7 93.27,51.28 92.56,50.57 92.56,50.28 92.76,50.08 94.43,50.08
  BOTTOM w0.089: U7.AT12 v1(79.37,64.67)
M_B_DQSP3: length 29.5
  TOP w0.127: U27.C7 100.82,50.34 101,50.17 v3(101,50.17)
  IN1 w0.089: 98.95,51.72 98.95,51.69 98.97,51.66 98.97,51.37 99.84,50.51 99.84,49.97 99.95,49.85 100.01,49.85 100.06,49.81 100.49,49.81 100.61,49.93 100.61,50.29 100.62,50.3 100.62,50.32 100.89,50.59 101.13,50.59 101.2,50.52 101.2,50.37 v3(101,50.17)
  IN1 w0.14: v1(91.33,59.63) 91.48,59.63 91.64,59.47 91.64,59.25 91.5,59.11 91.12,59.11 90.98,58.97 90.98,58.78 91.21,58.54 93.18,58.54 93.32,58.69 94.72,58.69 95.47,57.93 95.47,57.37 97.25,55.6 98.05,55.6 99.22,54.43 99.22,52.15 98.95,51.88 98.95,51.72
  BOTTOM w0.102: U7.AY2 83.83,63.32 83.92,63.41 84.07,63.41 84.27,63.21 84.89,63.21 85.38,62.72 87.23,62.72 88.72,61.24 88.72,61.21 88.73,61.2 88.73,61.16 88.75,61.15 88.75,61.07
  BOTTOM w0.127: 88.75,61.07 88.75,60.96 89.15,60.55 90.55,60.55 91.07,60.03 91.07,59.88 v1(91.33,59.63)
M_B_DQSP4: length 12
  BOTTOM w0.089: U7.BH14 77.69,59.04 77.69,58.93 77.7,58.91 77.7,58.47 77.82,58.35 77.82,57.86 77.82,57.86 77.82,57.66 77.78,57.62 77.78,57.61 77.77,57.6
  BOTTOM w0.102: 77.77,57.6 77.62,57.46 77.29,57.46 77.22,57.39 77.22,57.15 77.3,57.07 77.74,57.07 77.93,56.88 77.93,55.61 78.37,55.16 78.37,55.06 79.2,54.23 79.2,53.93 81.21,51.92 81.21,51.47 80.74,51 80.05,51 79.62,50.57 U34.C7
M_B_DQSP5: length 23.4
  TOP w0.089: v3(80.64,49.9) 80.79,49.9 80.85,49.83 80.85,49.77 80.92,49.7 80.92,49.32 80.19,48.59 80.19,48.17 79.82,47.79 79.7,47.79 79.62,47.88 U26.F3
  IN1 w0.089: 79.85,50.96 79.86,50.96 79.91,51.01 80.28,51.01 80.35,51.01 80.64,50.71 80.64,50.45 80.86,50.23 80.86,50.12 v3(80.64,49.9) ; v1(74.33,64.95) 74.33,65.12 74.52,65.3 74.87,65.3 75.21,64.96 75.21,59.03 75.38,58.86 75.38,58.83 75.5,58.71
  IN1 w0.14: 79.85,50.96 79.22,50.96 77.57,52.61 77.42,52.77 77.42,53.66 76.22,54.85 76.22,57.22 75.77,57.67 75.77,58.44 75.5,58.71
  BOTTOM w0.089: U7.AT22 v1(74.33,64.95)
M_B_DQSP6: length 24.6
  IN2 w0.089: 72.88,58.41 72.88,58.81 72.93,58.87 72.93,61.58 73.07,61.71 73.24,61.71 73.34,61.61 v1(73.34,61.39)
  IN2 w0.14: v3(81.37,48.5) 81.48,48.61 81.48,48.88 81.36,49 81.15,49 80.8,48.65 80.44,48.65 79.88,49.2 79.88,49.75 78.43,51.21 74.57,51.21 74.09,50.72 73.72,50.72 73.42,51.02 73.42,51.75 73.15,52.03 73.15,54.28 72.88,54.55 72.88,57.07 72.88,57.07 72.88,58.41
  BOTTOM w0.089: v1(73.34,61.39) U7.BC24 ; U34.F3 82.82,48.17 82.82,47.91 82.77,47.86 82.43,47.86 82.01,48.28 81.71,48.28 81.71,48.28 81.54,48.28 81.52,48.29 81.46,48.29 81.37,48.38 v3(81.37,48.5)
M_B_DQSP7: length 16.2
  TOP w0.076: 82.71,50.83 82.4,50.83 81.91,51.33 81.91,51.48 81.72,51.66 81.33,51.66 81.11,51.88 81.11,52.24 79.13,54.23 79.08,54.23 78.76,54.54 78.23,54.54 78.21,54.52 78.19,54.52
  TOP w0.089: 82.71,50.83 82.82,50.73 U26.C7
  TOP w0.127: 78.19,54.52 75.59,54.52 74.77,55.33 74.77,55.67 74.23,56.21 73.72,56.21 v1(73.43,55.92)
  BOTTOM w0.102: 73.98,58.26 73.98,58.31 73.85,58.44 73.85,58.7 73.84,58.71 73.84,58.93 73.83,58.94 U7.BH22
  BOTTOM w0.127: v1(73.43,55.92) 73.43,56.02 73.6,56.2 73.91,56.2 74.14,56.43 74.14,57.27 73.98,57.43 73.98,58.26
M_B_DRAMRST#: length 80.2
  TOP w0.102: U27.T2 96.35,39.92 96.35,38.19 98.46,36.08 98.48,36.08 98.48,36.07 99,36.07 v1(99.36,36.43) ; U26.T2 78.82,37.74 79.72,36.84 79.72,36.56 79.94,36.34 80.09,36.34 80.46,35.97 81.23,35.97 v3(81.6,36.34)
  IN1 w0.089: v1(79.21,62.1) 79.61,61.7 79.61,59.74 80.12,59.23 80.64,59.23 81.57,58.29
  IN1 w0.135: v1(89.92,36.04) 89.92,36.06 88.84,37.14 88.84,41.15 89.23,41.54 89.23,42.52 88.97,42.78 88.61,42.78 88.11,43.27 88.11,43.87 88.88,44.64 88.88,44.7 88.88,44.7 88.88,45.3 89.18,45.6 89.18,45.8 89.74,46.36 89.74,48.82 86.13,52.42 86.13,52.84 85.16,53.81 85.15,53.81 84.99,53.98 84.36,53.98 81.57,56.76 81.57,58.29
  IN2 w0.102: v1(99.36,36.43) 99.06,36.13 99.06,35.65 98.29,34.88 97.31,34.88 97.01,35.18 96.63,35.18 96.33,35.49 95.83,35.49 95.19,34.85 91.64,34.85 91.32,35.18 91.32,35.19 91.08,35.42 91.07,35.42 90.46,36.04 v1(89.92,36.04) 89.53,36.04 89.36,36.2 88.36,36.2 88.26,36.1 88.26,35.76 88.16,35.65 87.95,35.65 87.85,35.76 87.85,36.1 87.75,36.2 87.55,36.2 87.44,36.1 87.44,35.76 87.34,35.65 87.14,35.65 87.04,35.76 87.04,36.1 86.94,36.2 86.73,36.2 86.63,36.1 86.63,35.76 86.53,35.65 86.33,35.65 86.22,35.76 86.22,36.1 86.12,36.2 82.19,36.2 82.06,36.34 v3(81.6,36.34)
  BOTTOM w0.089: U7.BA12 v1(79.21,62.1)
  BOTTOM w0.102: v3(81.6,36.34) 81.9,36.64 82.35,36.64 82.54,36.83 82.54,36.97 82.31,37.21 82.31,37.35 82.45,37.49 82.59,37.49 82.83,37.26 82.98,37.26 83.21,37.49 83.21,37.57 83.38,37.74 83.38,37.94 83.33,37.99 83.33,38.12 83.62,38.41 U34.T2 ; v1(99.36,36.43) 99.68,36.75 99.8,36.75 100.04,36.51 100.27,36.51 100.83,37.07 100.83,37.3 100.59,37.54 100.59,37.66 100.69,37.76 100.84,37.76 100.95,37.65 101.07,37.65 101.2,37.77 101.2,37.95 101.1,38.05 101.1,38.17 101.4,38.47 U33.T2
M_B_ODT0: length 81.5
  TOP w0.089: 73.92,57.47 74.66,57.47 74.77,57.58 74.77,57.72 74.7,57.79 73.85,57.79 73.77,57.87 73.77,58.02 73.85,58.1 74.81,58.1 74.89,58.18 74.89,58.33 74.81,58.41 74.26,58.41 74.15,58.52 74.15,58.65 74.24,58.74 75.64,58.74 75.78,58.89 75.78,63.39 75.91,63.53 v1(76.24,63.53) ; v3(80.94,44.86) 80.94,44.82 80.85,44.74 80.71,44.74 80.55,44.58 80.34,44.58 80.27,44.52 78.95,44.52 78.92,44.49 77.8,44.49 77.71,44.58 77.71,44.88 77.8,44.97 U26.K1 ; U27.K1 96.13,44.64 97.6,44.64 97.78,44.82 98.17,44.82 98.3,44.69 99.02,44.69 v3(99.05,44.72)
  TOP w0.117: 73.92,57.47 73.8,57.35 73.8,57.1 73.93,56.97 74.86,56.97 75.17,57.28 76.07,57.28 76.93,56.42 79.38,56.42 80.06,55.74 80.06,55.74 80.23,55.58 80.44,55.58 80.6,55.73 80.81,55.73 81.67,54.87 81.67,54.61 82.23,54.06 82.8,54.06 83.04,54.29 83.77,54.29 83.92,54.15 83.92,53.67 84.2,53.39 85.38,53.39 85.69,53.7 85.87,53.7 86.12,53.46 86.12,53.28 85.96,53.11 85.96,52.93 86.13,52.75 86.31,52.75 86.48,52.92 87.59,52.92 87.76,52.75 87.76,52.57 87.27,52.08 87.27,51.83 87.37,51.73 87.85,51.73 87.95,51.62 87.95,51.19 87.83,51.06 87.53,51.06 87.4,50.94 87.4,50.64 87.53,50.52 87.82,50.52 87.95,50.38 87.95,50.11 87.79,49.95 87.03,49.95 86.9,49.82 86.9,49.57 87.03,49.44 87.79,49.44 87.95,49.28 87.95,47.07 87.79,46.91 87.29,46.91 87.16,46.78 87.16,46.42 87.28,46.3 87.74,46.3 87.88,46.16 87.88,45.82 87.97,45.72 v3(87.97,45.28)
  IN2 w0.089: v3(80.94,44.86) 81.24,45.16 82.3,45.16 82.91,44.56 84.48,44.56 84.52,44.59 84.72,44.59 84.83,44.7 84.83,45.11 84.92,45.2 85.16,45.2 85.25,45.11 85.25,44.62 85.33,44.53 85.57,44.53 85.66,44.62 85.66,45.11 85.74,45.2 85.99,45.2 86.08,45.11 86.08,44.6 86.16,44.52 86.44,44.52 86.53,44.6 86.53,44.78 86.63,44.89 86.84,44.89 86.93,44.79 86.93,44.58 87.01,44.5 88.32,44.5 88.53,44.71 88.53,44.88 88.45,44.95 88.08,44.95 87.97,45.06 v3(87.97,45.28) 88.13,45.43 88.57,45.43 88.64,45.51 89.29,45.51 89.36,45.43 94.1,45.43 94.35,45.68 94.69,45.68 94.84,45.53 94.92,45.53 95.91,44.55 97.24,44.55 97.44,44.75 99.02,44.75 v3(99.05,44.72)
  BOTTOM w0.089: R1102.2 88.02,45.23 v3(87.97,45.28) ; v3(99.05,44.72) 99.46,44.72 99.58,44.6 100.1,44.6 100.15,44.65 101.1,44.65 101.24,44.51 101.85,44.51 102.2,44.86 U33.K1 ; v3(80.94,44.86) 81.2,45.13 82.24,45.13 82.49,44.87 82.49,44.83 82.68,44.64 82.95,44.64 82.97,44.66 83.51,44.66 83.61,44.57 84.02,44.57 84.18,44.73 84.18,44.73 U34.K1 ; U7.AV18 v1(76.24,63.53)
M_B_RAS#: length 74.8
  TOP w0.089: U27.J3 97.75,45.77 97.81,45.83 98.02,45.83 98.2,46 98.72,46 98.93,45.8 98.93,45.69 99.04,45.58 99.43,45.58 99.52,45.67 v3(99.52,45.67) ; U26.J3 80.17,45.77 80.18,45.77 80.19,45.77 80.46,46.04 80.55,46.04 80.64,46.13 80.64,46.33 80.72,46.42 81.07,46.42 81.46,46.03 v3(81.46,45.76) ; 78.14,57.31 77.71,57.31 77.63,57.38 77.63,57.51 77.81,57.69 77.81,60.21 77.78,60.24 77.78,61.83 77.86,61.91 77.86,62.07 77.98,62.19 78.13,62.19 v1(78.22,62.1)
  TOP w0.117: 78.14,57.31 79.68,57.31 80.41,56.58 81.23,56.58 81.47,56.82 81.69,56.82 82.06,56.46 82.06,56.28 81.87,56.09 81.87,55.91 82.05,55.73 82.23,55.73 82.41,55.92 82.59,55.92 83.48,55.03 84.34,55.03 84.7,54.67 84.7,54.29 84.82,54.16 85.08,54.16 85.21,54.29 85.21,54.55 85.33,54.68 85.81,54.68 86.28,55.15 86.56,55.15 86.83,54.88 86.98,54.88 88.47,53.39 88.62,53.39 90.33,51.68 90.33,50.98 90.2,50.85 88.93,50.85 88.81,50.73 88.81,50.47 88.93,50.35 90.2,50.35 90.33,50.22 90.33,49.97 90.2,49.84 88.93,49.84 88.81,49.71 88.81,49.46 88.93,49.33 90.2,49.33 90.33,49.2 90.33,48.95 90.2,48.82 88.93,48.82 88.81,48.7 88.81,48.44 88.93,48.31 90.2,48.31 90.33,48.19 90.33,47.93 90.2,47.81 88.93,47.81 88.81,47.68 88.81,47.43 88.93,47.3 90.2,47.3 90.33,47.17 90.33,45.87 90.2,45.75 89.99,45.75 89.75,45.99 89.75,46.54 89.64,46.65 v1(89.29,46.65)
  IN2 w0.102: v3(81.46,45.76) 81.52,45.7 82.37,45.7 83.11,44.96 84.27,44.96 84.43,45.11 84.43,45.46 84.57,45.6 86.23,45.6 86.33,45.7 86.34,45.7 86.56,45.92 86.56,45.92 86.69,46.06 86.97,46.06 87.09,46.17 87.09,46.38 87.19,46.48 87.43,46.48 87.54,46.38 87.54,46.07 87.64,45.97 87.87,45.97 87.98,46.07 87.98,46.12 88,46.14 88,46.74 88.1,46.84 88.38,46.84 88.45,46.77 88.45,46.45 88.7,46.21 88.86,46.21 88.97,46.33 88.97,46.55 89.08,46.65 v1(89.29,46.65) 89.58,46.65 90.13,46.1 94.83,46.1 95,45.92 95.08,45.92 96.07,44.94 97.08,44.94 97.69,45.55 99.4,45.55 99.52,45.67 v3(99.52,45.67)
  BOTTOM w0.089: v3(99.52,45.67) 99.57,45.72 99.57,45.94 99.72,46.09 100.08,46.09 100.22,45.94 100.22,45.52 100.31,45.43 100.55,45.43 100.6,45.48 U33.J3 ; U7.BA14 v1(78.22,62.1) ; v3(81.46,45.76) 81.46,46.16 81.57,46.27 81.77,46.27 81.86,46.18 81.86,46.03 81.95,45.94 82.12,45.94 82.21,46.03 82.21,46.15 82.34,46.28 82.5,46.28 82.54,46.24 82.69,46.24 82.81,46.12 82.81,46.11 82.82,46.11 82.82,45.77 U34.J3
  BOTTOM w0.117: v1(89.29,46.65) 89.4,46.76 R1086.2
M_B_WE#: length 66.8
  TOP w0.089: U26.L3 79.75,44.17 80.12,43.8 80.63,43.8 80.85,44.02 80.85,44.06 81.04,44.24 81.37,44.24 v3(81.71,44.58) ; U27.L3 97.62,44.39 98.77,44.39 99.07,44.09 99.47,44.09 99.48,44.08 v3(99.49,44.08)
  IN1 w0.135: v1(90.74,44.3) 91.15,44.3 91.29,44.44 91.29,44.75 91.4,44.86 91.4,45.38 91.4,45.38 91.4,46.63 91.06,46.97 91.06,48.43 91.59,48.96 91.59,49.37 91.31,49.65 90.83,49.65 90.55,49.93 90.55,50.15 91.31,50.91 91.31,51.42 91.17,51.56 90.92,51.56 90.04,50.68 89.79,50.68 89.54,50.93 89.54,51.18 90.45,52.1 90.45,52.35 90.18,52.63 89.95,52.63 89.08,51.75 88.83,51.75 88.65,51.93 88.65,52.4 88.94,52.7 88.94,52.95 88.61,53.28 88.41,53.28 88.04,52.91 87.79,52.91 87.61,53.09 87.61,53.47 87.98,53.84 87.98,54.09 87.85,54.22 86.53,54.22 v1(86.45,54.14)
  IN2 w0.102: v3(99.49,44.08) 98.85,44.08 98.61,44.32 97.58,44.32 97.39,44.13 95.75,44.13 95.33,44.56 94.22,44.56 93.95,44.82 91.13,44.82 90.98,44.67 90.98,44.54 v1(90.74,44.3) 90.37,44.3 90.13,44.54 88.94,44.54 88.48,44.08 82.8,44.08 82.4,44.49 81.79,44.49 v3(81.71,44.58)
  BOTTOM w0.089: U33.L3 100.82,44.17 100.91,44.26 100.91,44.39 100.82,44.48 100.44,44.48 100.15,44.19 99.96,44.19 99.83,44.31 99.72,44.31 v3(99.49,44.08) ; U7.BH10 79.66,58.44 79.81,58.29 79.81,56.8 81.51,55.1 81.51,55.1 82.57,54.05 ; v3(81.71,44.58) 81.71,44.76 81.85,44.91 82.08,44.91 82.17,44.82 82.17,44.38 82.28,44.28 82.4,44.28 82.56,44.44 82.81,44.44 82.89,44.36 82.89,44.24 U34.L3
  BOTTOM w0.102: v1(86.45,54.14) 86.66,54.36 86.66,54.56 86.56,54.66 85.49,54.66 85.39,54.56 85.39,54.08 85.27,53.96 85.09,53.96 84.99,54.06 84.99,54.81 84.89,54.91 84.69,54.91 84.58,54.8 84.58,54.08 84.46,53.96 84.28,53.96 84.17,54.06 84.17,54.81 84.07,54.91 83.87,54.91 83.77,54.8 83.77,54.08 83.65,53.96 83.46,53.96 83.36,54.06 83.36,54.81 83.26,54.91 83.06,54.91 82.95,54.8 82.95,54.19 82.82,54.05 82.57,54.05
  BOTTOM w0.117: v1(90.74,44.3) 90.74,44.78 90.86,44.9 R1095.2
M_B_ZQ1: length 9.1
  TOP w0.117: U27.L8 101.75,43.82 102.94,43.82 103.33,43.43 103.33,37.33 R1104.2
M_B_ZQ2: length 11.1
  BOTTOM w0.108: R1076.2 94.29,37.23 94.29,39.06 93.27,40.07 93.27,43.1 94.11,43.94 95.48,43.94 95.63,43.78 96.21,43.78 U33.L8
M_B_ZQ3: length 5.1
  BOTTOM w0.102: 78.52,43.87 U34.L8
  BOTTOM w0.127: R1077.2 76.62,44.55 77.41,43.75 77.81,43.75 77.84,43.79 78.44,43.79 78.52,43.87
M_B_ZQ4: length 9
  TOP w0.102: U26.L8 84.06,43.73 84.8,43.73 85.42,43.11 85.42,42.31 86.2,41.53 86.2,41.2 85.82,40.83 R1078.2
MAIND: length 64.4
  TOP w0.254: v1(95.27,100.4) 95.15,100.28 95.15,98.32 95.71,97.75 PQ23.3 97.38,97.75 v1(97.46,97.83) 97.71,97.83 98.29,97.26 PC127.2 PR143.2 ; PQ29.4 114.76,111.36 114.55,111.58 114.24,111.58 v1(114.03,111.37)
  IN1 w0.254: v1(125.59,97.33) 125.59,96.7 125.35,96.46 122.91,96.46 120.55,98.82 120.19,98.82 118.85,100.17 118.85,102.37 118.86,102.38 118.86,103.64 118.45,104.04 118.45,108.99 116.23,111.22 114.18,111.22 v1(114.03,111.37)
  IN2 w0.254: v1(114.03,111.37) 114.03,111.59 113.83,111.79 102.03,111.79 99.76,109.52 96.07,109.52 95.65,109.1 95.65,100.78 v1(95.27,100.4)
  BOTTOM w0.254: PQ2.2 97.28,101.64 96.83,101.18 96.05,101.18 v1(95.27,100.4) ; PQ4.4 v1(125.59,97.33)
MAINON: length 287.4
  TOP w0.203: R254.1 124.8,26.3 U9.30
  TOP w0.254: v1(119.64,98.59) 119.74,98.49 120.52,98.49 121.34,99.31 121.34,102.17 PQ22.2 119.83,102.91 119.49,102.57 118.43,102.57 PR141.1 117.79,105.31 116.77,106.34 v1(116.18,106.34) PR232.1 ; R254.1 123.83,26.25 123.06,26.25 122.05,27.27 v1(122.05,27.6) ; PR154.2 47.03,68.01 47.03,66.37 48.06,65.34 48.06,60.89 43.9,56.73 37.85,56.73 37.22,56.11 v1(35.99,56.11) ; v1(112.98,31.66) 112.98,32.2 110.52,34.66 104.04,34.66 102.91,33.53 v1(101.89,33.53) ; v1(126.43,70.32) 126.14,70.61 126.14,71.08 125.75,71.47 125.75,74.69 125.24,75.2 124.16,75.2 123.86,75.51 123.86,79.25 120.57,82.54 120.57,85.73 118.84,87.45 118.84,91.52 119.22,91.9 119.22,93.67 118.26,94.63 v1(116.97,94.63) 116.54,95.06 112.49,95.06 109.53,92.1 104.05,92.1 100.91,95.24 100.91,97.91 102.59,99.59 103.76,99.59 104.21,100.04 v1(105.36,100.04)
  IN1 w0.254: v1(101.89,33.53) 101.83,33.59 97.07,33.59 96.66,33.18 93.2,33.18 91.94,31.92 77.57,31.92 76.83,31.18 42.07,31.18 40.41,32.84 38.25,32.84 35.45,35.64 35.45,43.64 36.6,44.79 36.6,45.55 38.41,47.35 38.41,53.1 35.99,55.51 v1(35.99,56.11) ; v1(116.97,94.63) 118.29,95.95 120.91,95.95 121.54,96.59 121.54,97.27 120.46,98.35 119.88,98.35 v1(119.64,98.59)
  IN2 w0.254: v1(122.05,27.6) 121.29,26.84 118.84,26.84 116.59,29.1 116.59,29.68 116.45,29.82 115.77,29.82 114.63,30.97 114.28,31.31 113.34,31.31 v1(112.98,31.66) 112.98,32.53 112.62,32.89 112.62,36.03 113.86,37.27 113.86,40.5 114.89,41.53 114.89,45.09 114.63,45.35 114.63,45.96 115.09,46.42 115.09,47.59 114.92,47.76 114.92,49.04 114.34,49.62 114.34,53.4 v1(114.19,53.54) 114.19,54.1 112.68,55.62 112.68,56.66 113.18,57.17 113.18,61.35 112.58,61.95 112.58,63.86 115.95,67.22 121.03,67.22 121.34,67.53 121.95,67.53 122.52,68.09 124.2,68.09 v1(126.43,70.32)
  BOTTOM w0.254: PR3.1 105.33,100.07 v1(105.36,100.04) ; v1(114.19,53.54) 115.51,54.86 116.95,54.86 117.21,54.59 117.99,54.59 PR195.1 ; PR118.2 32.51,53.93 34.69,56.11 v1(35.99,56.11)
MAINON_ON_G: length 91.9
  TOP w0.254: 95.25,95.72 95.25,97.7 94.78,98.17 94.78,100.16 v1(94.57,100.36) 94.57,102.9 92.13,105.35 88.37,105.35 87.63,104.61 87.63,102.22 86.34,100.93 85.12,100.93 84.86,100.68 PQ18.2 ; PR142.1 PR144.2 119.5,106.16 v1(121.51,106.16) 122.58,105.1 PQ22.3 122.58,101.77 122.07,101.25 122.07,96.32 124.37,94.02 124.37,84.57 v1(124.57,84.37) ; v1(107.78,89.38) 107.78,88.8 107.68,88.7 PQ20.2 106.96,87.72 106.84,87.59 Q79.2
  IN1 w0.254: v1(94.57,100.36) 94.57,99.06 98.39,95.25 98.39,92.99 100.68,90.69 102.73,90.69 103.92,89.51 107.65,89.51 v1(107.78,89.38) 107.78,89.09 108.01,88.86 110.54,88.86 111.19,89.51 113.53,89.51 114.18,88.86 118.72,88.86 121.18,86.39 121.87,86.39 123.89,84.37 v1(124.57,84.37)
MBCLK: length 107.2
  TOP w0.203: U9.110 135.5,40.6
  TOP w0.254: v1(137.7,41.96) 137.7,42.47 R213.1 138.25,42.75 138.25,41.72 137.93,41.4 137.76,41.4 137.11,40.76 135.65,40.76 135.5,40.6 ; 108.15,26.46 108.15,25.49 107.52,24.86 107.52,21.9 106.18,20.56 104.59,20.56 100.55,16.52 71.43,16.52 70.16,17.79 70.16,18.78 69.87,19.07 PC168.1 PR226.2 70.22,20.07 70.87,20.72 PD10.1 ; 108.15,26.46 v1(108.15,26.48) ; 108.15,26.46 106.99,26.46 v1(106.5,25.97) 106.5,24.5 106.12,24.12 105.14,24.12 104.11,25.15 104.11,25.79 PR114.2
  IN1 w0.254: v1(108.15,26.48) 108.15,26.51 109.13,27.49 116.04,27.49 116.94,28.39 118.84,28.39 118.97,28.51 123.06,28.51 123.54,28.04 124.39,28.04 124.86,28.51 126.44,28.51 126.98,27.98 128.94,27.98 129.8,27.12 131.44,27.12 132.13,27.81 132.74,27.81 133.18,28.25 134.02,29.08 134.02,29.08 135.28,30.34 135.28,33.52 135.76,34.01 135.76,36.41 136.25,36.89 136.25,39.11 137.7,40.56 v1(137.7,41.96)
MBCLK2: length 69.3
  TOP w0.108: U9.115 133.5,40.44 134.63,41.57 134.63,42.26 R216.1 134.91,42.88 134.83,42.96 134.83,44.91 R1023.1 134.81,45.71 134.81,48.98 134.49,49.29 134.49,50.01 133.94,50.56 133.22,50.56 132.74,50.08 v1(132.44,50.08)
  IN2 w0.14: v1(108.33,67.35) 107.82,66.84 107.82,66.31 108.57,65.56 109.98,65.56 110.76,64.79 110.76,57.58 109.91,56.72 109.91,55.59 109.46,55.14 109.46,54.68 110.46,53.68 111.37,53.68 112.73,52.32 112.73,49.61 v1(112.49,49.36)
  BOTTOM w0.108: v1(108.33,67.35) 108.04,67.06 108.04,66.12 107.49,65.57 U8.8 ; v1(132.44,50.08) 133.04,49.48 133.04,45.35 131.2,43.5 124.06,43.5 123.74,43.83 118.69,43.83 118.23,44.29 117.7,44.29 117.42,44.57 117.42,45.16 113.54,49.04 112.81,49.04 v1(112.49,49.36)
MBDATA: length 97.9
  TOP w0.203: U9.111 135.1,40.48
  TOP w0.254: PD9.1 72.65,20.69 73.26,20.07 PR225.2 PC167.1 73.63,19.07 73.37,18.82 73.37,17.96 74.3,17.02 100.34,17.02 104.38,21.07 105.96,21.07 106.68,21.78 v1(106.68,23.61) ; v1(106.68,23.61) 104.93,23.61 104.6,23.95 104.6,24.12 103.75,24.96 103.75,25.25 PR117.2 ; v1(106.68,23.61) 107.01,23.94 107.01,25.33 v1(107.61,25.94) ; v1(137.17,41.52) 137.17,42.87 R212.1 136.95,42.88 135.1,41.03 135.1,40.48
  IN1 w0.254: v1(107.61,25.94) 107.61,25.94 107.61,26.69 108.92,27.99 115.83,27.99 116.73,28.9 118.63,28.9 118.76,29.02 123.27,29.02 123.75,28.55 124.18,28.55 124.65,29.02 126.65,29.02 127.19,28.49 129.15,28.49 130.01,27.63 131.23,27.63 131.92,28.32 132.53,28.32 134.77,30.55 134.77,33.79 135.21,34.23 135.21,36.57 135.74,37.1 135.74,39.32 137.17,40.76 v1(137.17,41.52)
MBDATA2: length 68.2
  TOP w0.108: v1(132.36,49.42) 132.51,49.42 133.4,50.31 133.88,50.31 134.23,49.96 134.23,49.25 134.59,48.89 134.59,45.78 R1024.1 134.62,44.78 134.62,43.07 134.43,42.88 R215.1 134.11,42.51 134.34,42.28 134.34,41.59 133.1,40.35 U9.116
  IN2 w0.14: v1(108.03,67.94) 107.54,67.45 107.54,66.2 108.46,65.28 109.87,65.28 110.48,64.67 110.48,57.69 109.63,56.84 109.63,55.7 109.18,55.26 109.18,54.56 110.34,53.4 111.25,53.4 112.45,52.2 112.45,50.26 v1(112.04,49.85)
  BOTTOM w0.108: U8.7 107.4,66.22 107.82,66.64 107.82,67.73 v1(108.03,67.94) ; v1(132.36,49.42) 132.82,48.95 132.82,45.44 131.11,43.72 124.15,43.72 123.82,44.05 119.12,44.05 117.7,45.48 117.4,45.48 113.1,49.78 112.11,49.78 v1(112.04,49.85)
MCSI_COMP: length 1.5
  TOP w0.254: v1(62.76,76.32) 62.74,76.29 R366.1
  BOTTOM w0.254: U7.P44 62.76,76.14 v1(62.76,76.32)
MIC2-VREFO: length 43.8
  TOP w0.203: v1(4.36,18.57) 4.55,18.57 4.72,18.4 U4.29
  TOP w0.381: R65.2 17.44,48.47 16.92,47.95 v1(16.92,47.77) ; R66.2 6.48,36.42 v1(6.48,35.78)
  IN2 w0.381: v1(4.36,18.57) 2.87,20.06 2.87,23.54 2.26,24.15 2.26,31.16 3.76,32.65 5.64,32.65 6.48,33.49 v1(6.48,35.78) 6.48,36.26 7.57,37.35 13.4,37.35 15.07,39.02 15.07,40.66 15.33,40.91 15.33,43.89 15.37,43.93 15.37,43.94 17.07,45.64 17.07,47.62 v1(16.92,47.77)
MX0: length 19.6
  TOP w0.108: U9.58 138.3,22.72 v1(138.14,22.57)
  IN2 w0.14: v1(138.14,22.57) 138.14,26.14 134.81,29.48 v1(132.94,29.48)
  BOTTOM w0.108: v1(132.94,29.48) 133.73,29.48 134.23,29.98 CN11.1 134.23,30.79 134.73,31.29 134.73,31.76 134.72,31.77 134.72,34.28 134.11,34.89 RP1.1
MX1: length 19.8
  TOP w0.108: v1(138.79,22.55) 138.7,22.65 U9.59
  IN2 w0.14: v1(132.23,29.48) 132.77,30.01 134.67,30.01 138.79,25.89 v1(138.79,22.55)
  BOTTOM w0.108: RP1.2 133.58,34.25 134.09,33.75 134.09,31.97 133.72,31.6 133.47,31.6 133.23,31.36 CN11.2 133.23,30.37 132.34,29.48 v1(132.23,29.48)
MX2: length 21
  TOP w0.108: U9.60 139.1,23.12 139.44,22.78 v1(139.44,22.5)
  IN2 w0.14: v1(131.55,29.48) 132.2,28.83 135.07,28.83 137.69,26.2 137.69,22.77 137.68,22.76 137.68,22.37 137.96,22.09 139.03,22.09 v1(139.44,22.5)
  BOTTOM w0.108: RP1.3 133.63,33.62 133.87,33.38 133.87,32.06 133.63,31.82 133.18,31.82 132.23,30.87 CN11.3 132.23,30.16 v1(131.55,29.48)
MX3: length 24
  TOP w0.108: v1(140.08,22.4) 140.08,22.55 139.5,23.13 U9.61
  IN2 w0.14: v1(132.31,31.69) 130.99,30.37 130.99,29.28 131.95,28.31 135.19,28.31 137.42,26.08 137.42,22.89 137.4,22.87 137.4,22.26 137.85,21.81 139.49,21.81 v1(140.08,22.4)
  BOTTOM w0.108: RP1.4 133.5,32.98 133.66,32.83 133.66,32.15 133.54,32.04 132.66,32.04 v1(132.31,31.69) 132.13,31.69 131.23,30.79 CN11.4
MX4: length 34.1
  TOP w0.108: U9.62 139.9,23.13 140,23.02 140.05,23.02 141.33,21.74 v1(142.39,21.74) 144.63,21.74 v1(145.05,22.16)
  IN2 w0.14: v1(129.41,32.1) 129.66,31.85 130.52,31.85 130.94,32.27 136.61,32.27 139.23,29.66 141.64,29.66 142.28,29.02 142.28,23.59 144.18,21.69 144.58,21.69 v1(145.05,22.16)
  BOTTOM w0.108: CN11.5 130.23,31.07 129.41,31.88 v1(129.41,32.1) 129.54,32.22 130.43,32.22 130.56,32.35 RP1.6
MX5: length 33
  TOP w0.108: U9.63 140.3,23.13 141.27,22.16 v1(143.61,22.16) v1(144.37,22.16)
  IN2 w0.14: v1(144.37,22.16) 142.56,23.96 142.56,29.14 141.74,29.96 139.32,29.96 136.73,32.55 130.76,32.55 130.43,32.22 129.97,32.22 129.46,32.73 v1(129.16,32.73)
  BOTTOM w0.108: CN11.6 129.23,31.39 128.93,31.69 128.93,32.5 v1(129.16,32.73) 129.16,32.98 129.41,33.24 130.56,33.24 130.81,32.98 RP1.7
MX6: length 35.9
  TOP w0.108: U9.64 140.7,23.12 141.22,22.6 v1(141.43,22.6) 144.81,22.6 v1(145.05,22.83)
  IN2 w0.14: v1(145.05,22.83) 142.84,25.03 142.84,29.61 141.44,31.01 140.46,31.01 138.63,32.83 131.6,32.83 131.19,33.24 128.91,33.24 128.42,32.75 v1(128.42,31.85)
  BOTTOM w0.108: RP1.8 128.78,33.62 128.42,33.26 v1(128.42,31.85) 128.23,31.66 CN11.7
MX7: length 34.9
  TOP w0.108: U9.65 143.07,25.5 v1(145.05,23.53)
  IN2 w0.14: v1(145.05,23.53) 143.12,25.45 143.12,29.49 143.12,29.72 141.55,31.29 140.57,31.29 138.75,33.11 131.71,33.11 131.31,33.52 128.79,33.52 127.91,32.63 v1(127.91,32.24)
  BOTTOM w0.108: CN11.8 127.23,31.56 v1(127.91,32.24) 127.89,32.26 127.89,33.37 128.78,34.25 RP1.9
MY0: length 29.3
  TOP w0.108: v1(126.42,21.31) 126.84,21.72 127.16,21.72 128.02,22.58 129.09,22.58 129.5,23 U9.36
  IN2 w0.14: v1(126.42,21.31) 125.81,21.92 125.81,22.72 124.09,24.44 122.08,24.44 122.06,24.46 121.68,24.46 121.66,24.44 119.43,24.44 116.47,27.4 115.16,27.4 114.25,28.31 114.25,29.53 113.67,30.11 111.85,30.11 110.66,31.3 v1(110.66,32.25)
  BOTTOM w0.108: v1(110.66,32.25) 110.66,32.06 109.86,31.26 109.35,31.26 109.23,31.14 CN11.26
MY1: length 28.7
  TOP w0.108: U9.37 129.9,23.09 129.18,22.37 128.14,22.37 v1(127.08,21.31)
  IN2 w0.14: v1(127.08,21.31) 127.46,21.69 127.46,22.52 125.27,24.72 122.2,24.72 122.18,24.74 121.56,24.74 121.54,24.72 119.55,24.72 116.59,27.68 115.67,27.68 114.83,28.51 114.83,29.4 113.84,30.39 111.97,30.39 111.01,31.36 111.01,31.69 v1(111.13,31.81)
  BOTTOM w0.108: CN11.25 110.23,31.25 110.79,31.81 v1(111.13,31.81)
MY2: length 28.7
  TOP w0.108: v1(127.74,21.31) 128.59,22.15 129.27,22.15 129.68,22.57 129.8,22.57 130.3,23.07 U9.38
  IN2 w0.14: v1(112.17,32.2) 112.14,32.17 112.12,32.17 111.74,31.79 111.74,31.26 112.32,30.67 114.05,30.67 115.14,29.58 115.14,28.64 115.82,27.96 116.7,27.96 119.67,25 121.43,25 121.45,25.02 122.29,25.02 122.31,25 125.38,25 127.74,22.64 v1(127.74,21.31)
  BOTTOM w0.108: CN11.24 111.23,31.32 112.08,32.17 112.14,32.17 v1(112.17,32.2)
MY3: length 26.2
  TOP w0.108: v1(128.4,21.31) 129.03,21.94 129.39,21.94 129.76,22.31 129.97,22.31 130.7,23.04 U9.39
  IN2 w0.14: v1(128.4,21.31) 128.4,22.37 125.5,25.28 122.43,25.28 122.41,25.3 121.33,25.3 121.31,25.28 119.78,25.28 116.82,28.24 116.2,28.24 115.47,28.97 115.47,29.65 114.16,30.95 112.8,30.95 v1(112.23,31.53)
  BOTTOM w0.108: v1(112.23,31.53) CN11.23
MY4: length 26.2
  TOP w0.108: U9.40 131.1,23.06 130.14,22.09 129.85,22.09 v1(129.07,21.31)
  IN2 w0.14: v1(115.18,32.18) 115.18,31.93 116.12,30.99 117.14,30.99 119.86,28.26 122.87,28.26 124.28,26.85 124.7,26.43 125.05,26.43 125.07,26.41 125.78,26.41 129.07,23.12 v1(129.07,21.31)
  BOTTOM w0.108: v1(115.18,32.18) 115.12,32.23 114.79,32.23 113.89,31.33 113.41,31.33 113.23,31.15 CN11.22
MY5: length 25.4
  TOP w0.108: U9.41 131.5,23.08 v1(129.73,21.31)
  IN2 w0.14: v1(129.73,21.31) 129.73,22.86 125.88,26.71 124.82,26.71 124.48,27.05 122.98,28.54 120.02,28.54 117.29,31.27 116.5,31.27 115.82,31.95 v1(115.82,32.17)
  BOTTOM w0.108: CN11.21 114.23,31.17 114.32,31.26 114.91,31.26 v1(115.82,32.17)
MY6: length 24.5
  TOP w0.108: v1(130.39,21.31) 131.9,22.82 U9.42
  IN2 w0.14: v1(117.15,32.02) 120.35,28.82 123.1,28.82 124.68,27.24 124.93,26.99 125.16,26.99 125.16,26.99 125.99,26.99 130.39,22.59 v1(130.39,21.31)
  BOTTOM w0.108: v1(117.15,32.02) 116.69,31.56 116.31,31.56 116.18,31.44 115.51,31.44 115.23,31.15 CN11.20
MY7: length 24
  TOP w0.108: U9.43 132.3,22.92 131.05,21.66 v1(131.05,21.31)
  IN2 w0.14: v1(131.05,21.31) 131.05,22.33 126.1,27.27 125.05,27.27 123.22,29.1 122.18,29.1 121.21,30.06 119.51,30.06 117.81,31.77 v1(117.81,32.05)
  BOTTOM w0.108: v1(117.81,32.05) 117.1,31.33 116.43,31.33 116.23,31.13 CN11.19
MY8: length 23.4
  TOP w0.108: v1(131.71,21.31) 131.71,22.02 132.7,23.01 U9.44
  IN2 w0.14: v1(131.71,21.31) 131.71,22.06 128.73,25.04 125.58,28.19 123.4,30.37 121.7,30.37 121.44,30.62 120.04,30.62 118.85,31.81 v1(118.85,32.12)
  BOTTOM w0.108: v1(118.85,32.12) 118.83,32.12 118.07,31.36 117.6,31.36 117.23,30.98 CN11.18
MY9: length 22.8
  TOP w0.108: v1(132.37,21.31) 132.37,22.37 133.1,23.11 U9.45
  IN2 w0.14: v1(119.46,31.89) 119.46,31.6 120.15,30.9 121.56,30.9 121.81,30.65 123.52,30.65 125.78,28.39 128.93,25.24 132.37,21.8 v1(132.37,21.31)
  BOTTOM w0.108: v1(119.46,31.89) 119.08,31.51 118.54,31.51 118.23,31.2 CN11.17
MY10: length 22.4
  TOP w0.108: v1(133.03,21.31) 132.61,21.72 132.61,22.24 133.5,23.13 U9.46
  IN2 w0.14: v1(133.03,21.31) 133.03,21.53 123.63,30.93 121.93,30.93 121.67,31.18 120.5,31.18 120.14,31.54 v1(120.14,31.89)
  BOTTOM w0.108: CN11.16 119.23,30.95 120.14,31.87 v1(120.14,31.89)
MY11: length 22.8
  TOP w0.102: v1(135.13,21.31) 135.26,21.44
  TOP w0.108: 135.26,21.44 135.5,21.68 U9.51
  IN2 w0.14: v1(135.13,21.31) 134.65,21.78 133.17,21.78 123.75,31.21 122.04,31.21 121.79,31.46 121.08,31.46 v1(120.8,31.74)
  BOTTOM w0.108: v1(120.8,31.74) 120.23,31.16 CN11.15
MY12: length 22.4
  TOP w0.108: U9.52 135.9,21.42 v1(135.79,21.31)
  IN2 w0.14: v1(122.25,31.99) 122.76,31.49 123.86,31.49 133.29,22.06 135.03,22.06 v1(135.79,21.31)
  BOTTOM w0.108: v1(122.25,31.99) 121.23,30.97 CN11.14
MY13: length 22.3
  TOP w0.108: v1(136.45,21.31) 136.3,21.46 U9.53
  IN2 w0.14: v1(122.96,31.99) 123.17,31.79 123.95,31.79 133.4,22.34 135.41,22.34 v1(136.45,21.31)
  BOTTOM w0.108: v1(122.96,31.99) 122.23,31.26 CN11.13
MY14: length 22.7
  TOP w0.108: U9.54 136.7,21.72 v1(137.11,21.31)
  IN2 w0.14: v1(124.79,32.1) 124.85,32.04 124.85,31.3 133.52,22.62 135.8,22.62 v1(137.11,21.31)
  BOTTOM w0.108: CN11.12 123.23,31.32 124.08,32.18 124.71,32.18 v1(124.79,32.1)
MY15: length 22.5
  TOP w0.108: U9.55 137.1,23.07 136.97,22.94 136.97,22.11 v1(137.77,21.31)
  IN2 w0.14: v1(137.77,21.31) 136.18,22.9 133.64,22.9 125.48,31.06 v1(125.48,32.04)
  BOTTOM w0.108: v1(125.48,32.04) 125.05,31.61 124.59,31.61 124.23,31.25 CN11.11
MY16: length 25.2
  TOP w0.108: v1(125.34,22.18) 125.34,21.8 126.25,20.89 137.94,20.89 138.19,21.14 138.19,21.63 137.5,22.32 U9.56
  BOTTOM w0.108: CN11.10 125.23,29.86 125.5,29.59 125.5,22.33 v1(125.34,22.18)
MY17: length 26.6
  TOP w0.108: U9.57 137.9,22.92 137.72,22.74 137.72,22.4 138.4,21.72 138.4,21.05 138.03,20.68 125.71,20.68 125.71,20.68 v1(125.08,21.31)
  BOTTOM w0.108: CN11.9 126.23,29.78 125.76,29.31 125.76,21.99 v1(125.08,21.31)
NB670BST: length 5.4
  BOTTOM w0.203: 132.21,94.12 132.37,94.29 PU3.10
  BOTTOM w0.254: 132.21,94.12 132.21,93.61 131.93,93.32 131.53,93.32 131.24,93.61
  BOTTOM w0.381: 131.24,93.61 131.03,93.82 129.98,93.82
  BOTTOM w0.508: 129.98,93.82 128.87,94.93 PR35.1
NB670BST_S: length 1.4
  BOTTOM w0.508: PR35.2 129.2,93.18 PC53.1
NB670CLK: length 1.9
  TOP w0.254: PR18.1 136.63,95.39 v1(136.45,95.21)
  BOTTOM w0.203: PU3.5 136.32,95.09 v1(136.45,95.21)
NB670EN: length 5.5
  TOP w0.254: PC52.2 PR169.2 131.11,95.9 v1(131.19,95.9) 131.29,95.9 131.79,95.41 131.79,95.3 132.19,94.9 PR168.1
  BOTTOM w0.203: PU3.13 131.76,95.49 131.34,95.9 v1(131.19,95.9)
NB670ENLDO: length 3.5
  TOP w0.508: PR34.1 PR167.2 131.22,95 v1(131.22,95.24)
  BOTTOM w0.152: v1(131.22,95.24) 131.37,95.09 PU3.12
NB670PG: length 1.8
  BOTTOM w0.203: PU3.4 135.96,95.49 136.53,96.05 PR24.1
NB670SW:
  vias: v1(134.49,90.21)
NB671BST: length 2.6
  BOTTOM w0.203: 133.1,108.07 133.27,108.07 133.36,107.98 PU5.10
  BOTTOM w0.381: PR59.1 131.85,108.47 132.26,108.07 133.1,108.07
NB671BST_S:
  vias: v1(130.84,110.43)
NB671EN: length 4.6
  BOTTOM w0.203: 134.7,108.27 134.56,108.14 PU5.13
  BOTTOM w0.254: 134.7,108.27 135.02,108.59 135.15,108.59 135.77,109.21 PC73.2 PR80.1 PR77.1
NB671FB: length 4.2
  BOTTOM w0.203: 134.16,108.6 PU5.12
  BOTTOM w0.254: 134.16,108.6 134.43,108.87 PR71.1 134.48,108.88 134.62,108.88 135.01,109.26 v1(135.01,110.52) PR68.2
NB671PG: length 2.6
  BOTTOM w0.203: PR67.1 134.71,102.96 134.71,104 134.56,104.15 PU5.4
NB671SW:
  vias: v1(132.31,104)
NBSWON#: length 117
  TOP w0.108: R1158.2 138.81,43.92 R214.1 139.05,45.42 139.32,45.15 v1(139.32,44.99) ; v1(135.76,74.24) 137.42,74.24 137.81,74.63 138.09,74.91 138.17,74.96 138.18,75 138.27,75.09 138.27,76.54 139.32,77.59 139.32,77.99 139.93,78.6 140.84,78.6 141.08,78.83 141.08,79.72 141.5,80.15 141.5,80.36 141.8,80.65 141.8,81.16 142.01,81.37 142.01,84.06 141.83,84.24 141.83,84.75 141.73,84.85 141.73,86.32 142.5,87.09 146.1,87.09 146.79,87.77 146.79,94.01 147.91,95.13 147.91,99.76 v1(148.06,99.91) ; v1(110.55,36.58) 110.87,36.58 111.96,37.67 111.96,37.99 112.1,38.13 112.82,38.13 114.24,39.55 114.24,40.41 114.97,41.14 116.13,41.14 119.14,44.15 126.11,44.15 127.36,45.41 127.72,45.41 127.98,45.15 127.98,44.32 v1(127.96,44.3) 127.96,43.67 R1166.1
  IN2 w0.14: v1(140.6,41.63) 139.66,40.69 135.48,40.69 133.16,43.01 130.19,43.01 129.88,43.32 129.36,43.32 128.39,44.3 v1(127.96,44.3) ; v1(135.76,74.24) 136.58,74.24 136.88,73.94 136.88,70.59 138.79,68.68 138.79,68.27 140,67.06 140,64.08 140.84,63.24 140.84,56.08 139.6,54.84 139.6,45.27 v1(139.32,44.99)
  BOTTOM w0.108: CN3.9 147.65,100.32 v1(148.06,99.91) ; v1(140.6,41.63) 140.6,44.4 140.02,44.99 v1(139.32,44.99) ; v1(110.55,36.58) 110.35,36.38 110.35,35.72 110.01,35.38 109.6,35.38 C828.1 R816.2
NOVRP1: length 2.3
  BOTTOM w0.108: R1114.1 29.36,68.13 v1(29.36,67.42) 29.36,67.4 28.58,66.61 U35.25
NOVRP2: length 2.1
  BOTTOM w0.108: R1115.1 28.08,67.91 v1(28.08,67.35) U35.24
NOVRP3: length 2.1
  BOTTOM w0.108: U35.20 25.17,64.59 R1117.1
NOVRP4: length 1.9
  BOTTOM w0.108: U35.19 24.66,64.09 R1118.1
PCBEEP: length 2.2
  TOP w0.102: U4.12 12.13,20 12.24,20.11 v1(12.24,20.66) 12.24,20.86 C34.1
PCBEEP_EC: length 137.3
  TOP w0.102: v1(133.34,25.46) 132.97,25.09 129.07,25.09 128.7,24.72 U9.34 ; v1(19.84,38.29) 19.84,38.52 19.31,39.06 R1028.2 18.95,38.71 v1(18.95,38.29) 18.62,38.29 18.04,37.71 D7.2
  IN1 w0.14: v1(101.75,31.03) 103.55,31.03 104.91,29.67 106.44,28.13 106.44,26.06 108.15,24.36 116.89,24.36 118.09,25.56 123.67,25.56 123.86,25.75 128.01,25.75 129.16,24.6 132.49,24.6 v1(133.34,25.46)
  IN2 w0.14: v1(19.84,38.29) 19.84,37.23 20.09,36.98 20.09,33.87 22.42,31.54 29.87,31.54 30.2,31.87 32.54,31.87 32.92,32.25 36.74,32.25 41.2,27.79 53.61,27.79 56.22,30.4 96.74,30.4 97.12,30.02 100.74,30.02 v1(101.75,31.03)
PCH_AZ_CODEC_BITCLK: length 182.8
  TOP w0.102: v1(17.07,25.95) 16.78,25.66 16.78,19.44 16.27,18.92 C50.2 16.27,18.62 15.86,18.21 12.85,18.21 12.24,17.6 U4.6
  IN2 w0.14: v1(106.15,68.16) 106.15,66.86 106.52,66.49 106.99,66.01 108.24,64.76 109.65,64.76 109.96,64.46 109.96,57.91 108.66,56.61 108.66,54.34 110.12,52.88 110.83,52.88 111.44,52.27 111.44,51.25 111.08,50.89 111.08,49.89 112.29,48.68 112.29,44.79 111.99,44.48 111.99,41.29 110.07,39.37 110.07,38.56 109.04,37.54 109.04,34.04 107.93,32.93 107.93,28.06 107.15,27.28 107.15,22.4 105.68,20.93 103.54,20.93 99.4,16.79 64.23,16.79 56.98,24.05 51.66,24.05 48.06,20.44 45.54,20.44 44.81,19.7 44.68,19.7 44.15,19.17 44.15,18.08 43.41,17.34 40.59,17.34 36.27,21.66 36.27,22.39 33.25,25.42 33.25,27.9 32.74,28.41 30.21,28.41 29.15,29.47 20.36,29.47 19.66,28.77 19.66,27.63 19.43,27.39 19.43,27.39 17.99,25.95 v1(17.07,25.95)
  BOTTOM w0.102: R202.2 98.99,71.16 99.34,71.16 100.15,70.35 103.23,70.35 104.53,69.05 105.77,69.05 106,68.82 106,68.32 v1(106.15,68.16)
PCH_AZ_CODEC_RST#: length 175.2
  TOP w0.102: v1(18.14,28.59) 18.12,28.6 16.57,28.6 15.37,27.4 15.37,25.24 15.84,24.77 15.84,22.16 15.72,22.04 14.45,22.04 14.1,21.69 14.1,21.28 13.8,20.97 12.93,20.97 12.65,20.69 12.65,19.93 12.32,19.6 U4.11
  IN2 w0.14: v1(103.89,67.96) 103.96,67.89 103.96,67.18 108.64,62.5 108.64,58.45 107.34,57.16 107.34,53.8 109.42,51.72 109.42,51.28 109.75,50.95 109.75,49.34 110.87,48.23 110.87,46.45 110.18,45.76 110.18,44.5 110.34,44.34 110.34,41.51 108.75,39.92 108.75,39.11 107.72,38.09 107.72,34.59 106.61,33.48 106.61,29.97 101.58,24.93 101.58,23.38 98.55,20.36 98.55,18.51 98.26,18.21 64.68,18.21 57.26,25.63 50.95,25.63 47.1,21.78 46.15,21.78 45.26,22.67 41.63,22.67 41.25,23.05 39.59,23.05 39.19,23.45 39.19,28.72 37.11,30.8 32.94,30.8 32.66,30.51 30.06,30.51 29.77,30.8 19.38,30.8 18.14,29.56 v1(18.14,28.59)
  BOTTOM w0.102: R206.2 97.26,69.13 97.82,69.69 99.81,69.69 99.86,69.64 102.94,69.64 103.89,68.69 v1(103.89,67.96)
PCH_AZ_CODEC_SDIN0: length 189.7
  TOP w0.102: R63.2 16.26,20.72 16.3,20.77 16.3,25.97 v1(16.34,26.01)
  IN2 w0.102: v1(81.46,71.45) 81.47,71.45 82.32,72.3 83.29,72.3 83.64,71.95 86.23,71.95 86.59,71.59 88.75,71.59 88.77,71.57
  IN2 w0.14: v1(16.34,26.01) 16.09,26.26 16.09,27.08 16.45,27.44 18.37,27.44 18.64,27.71 18.64,27.72 18.87,27.95 18.87,29.43 19.71,30.27 29.55,30.27 30.62,29.19 32.38,29.19 32.72,29.53 36.09,29.53 37.82,27.8 37.82,24.07 39.42,22.47 41.08,22.47 41.44,22.11 45.04,22.11 45.92,21.22 47.73,21.22 51.18,24.68 51.18,24.68 51.34,24.83 57.3,24.83 64.56,17.58 98.38,17.58 99.09,18.29 99.09,20.11 102.13,23.16 102.13,24.73 107.14,29.74 107.14,33.26 108.26,34.37 108.26,37.86 109.28,38.89 109.28,39.7 110.87,41.29 110.87,44.56 110.72,44.72 110.72,45.54 111.5,46.33 111.5,48.35 110.29,49.56 110.29,51.17 109.96,51.5 109.96,51.94 107.88,54.02 107.88,56.94 109.17,58.23 109.17,62.72 105.06,66.84 105.06,68.39 104.82,68.63 102.87,68.63 101.29,67.05 100.71,67.05 99.44,68.32 99.44,68.57 97.64,70.37 97.18,70.37 96.93,70.63 96.5,70.63 96.39,70.73 94.05,70.73 93.29,71.48 90.85,71.48 90.76,71.57 88.77,71.57
  BOTTOM w0.102: U7.AD7 v1(81.46,71.45)
PCH_AZ_CODEC_SDOUT: length 178.6
  TOP w0.102: v1(18.18,26.89) 18.18,26.15 17.27,25.23 17.27,19.24 16.75,18.72 16.75,18.08 16.5,17.83 15.48,17.83 15.31,18 13.05,18 12.24,17.2 U4.5
  IN2 w0.14: v1(18.18,26.89) 18.47,27.17 18.48,27.17 18.9,27.6 18.9,27.61 19.14,27.84 19.14,29.24 19.89,29.99 29.45,29.99 30.51,28.93 32.95,28.93 33.19,29.17 35.84,29.17 37.55,27.46 37.55,22.3 38.01,21.85 44.9,21.85 45.78,20.96 47.84,20.96 51.45,24.57 57.19,24.57 64.45,17.31 99.19,17.31 103.33,21.45 105.46,21.45 106.37,22.36 106.37,28.59 107.41,29.63 107.41,33.15 108.52,34.26 108.52,37.75 109.55,38.78 109.55,39.59 111.47,41.51 111.47,44.7 111.77,45 111.77,48.46 110.55,49.68 110.55,51.1 110.92,51.47 110.92,52.06 110.62,52.36 109.91,52.36 108.14,54.13 108.14,56.83 109.44,58.12 109.44,62.83 105.54,66.73 v1(105.54,67.48)
  BOTTOM w0.102: v1(105.54,67.48) 105.06,67.96 105.06,68.39 104.89,68.56 104.34,68.56 103.03,69.87 99.95,69.87 99.84,69.98 99.39,69.98 R208.2
PCH_AZ_CODEC_SYNC: length 173.3
  TOP w0.102: v1(18.17,27.9) 18.17,27.89 16.19,27.89 15.6,27.3 15.6,25.34 16.07,24.86 16.07,22.06 15.82,21.81 14.54,21.81 14.33,21.6 14.33,21.16 13.91,20.74 13.03,20.74 12.85,20.56 12.85,19.77 12.28,19.2 U4.10
  IN2 w0.14: v1(18.17,27.9) 18.6,28.33 18.6,29.54 19.6,30.53 29.66,30.53 29.95,30.25 32.8,30.25 33.08,30.53 36.56,30.53 38.84,28.26 38.84,23.43 39.48,22.79 41.14,22.79 41.53,22.39 45.14,22.39 46.03,21.5 47.2,21.5 51.06,25.36 57.15,25.36 64.67,17.85 98.27,17.85 98.82,18.4 98.82,20.22 101.86,23.26 101.86,24.83 106.88,29.85 106.88,33.37 107.99,34.48 107.99,37.97 109.01,39 109.01,39.81 110.6,41.4 110.6,44.45 110.45,44.61 110.45,45.65 111.23,46.44 111.23,48.24 110.02,49.45 110.02,51.06 109.69,51.39 109.69,51.83 107.61,53.91 107.61,57.05 108.9,58.34 108.9,62.61 104.42,67.09 v1(104.42,67.48)
  BOTTOM w0.102: v1(104.42,67.48) 103.76,67.48 103.46,67.78 103.46,68.8 102.85,69.41 100.86,69.41 100.69,69.23 R203.2
PCH_BLON_EC: length 110.5
  TOP w0.108: v1(140.95,33.62) 141.11,33.62 141.44,33.95 141.44,34.51 141.63,34.7 U9.88
  IN1 w0.14: v1(49.22,28.86) 50.02,29.66 52.68,29.66 53.72,28.61 54.63,28.61 54.88,28.86 61.93,28.86 62.58,28.21 74.65,28.21 75.41,28.97 77.84,28.97 78.56,29.68 92.77,29.68 94.1,31.02 96.5,31.02 96.74,30.78 98.24,30.78 98.69,31.23 100.82,31.23 101.5,30.55 103.65,30.55 106.17,28.03 106.17,25.97 107.84,24.29 107.84,23.79 108.24,23.38 114.64,23.38 115.34,24.08 116.99,24.08 118.2,25.29 123.78,25.29 123.97,25.49 127.9,25.49 129.05,24.34 136.46,24.34 139.23,27.1 139.23,30.64 140.03,31.44 140.03,32.7 v1(140.95,33.62)
  BOTTOM w0.108: R72.2 48.09,28.86 v1(49.22,28.86)
PCH_DISP_ON: length 16.8
  IN1 w0.14: v1(49.24,89.7) 48.79,89.25 47.07,89.25 47.07,89.25 46.61,89.25 46.04,89.82 46.01,89.82 45.87,89.96 43.33,89.96 40.87,92.42 v1(40.87,92.65)
  BOTTOM w0.102: v1(40.87,92.65) 40.45,92.23 R300.1 39.98,91.84 39.45,92.37 Q22.3 ; U12.3 48.03,90.9 47.83,90.7 47.83,90.51 48.37,89.97 R384.2 49.24,89.69 v1(49.24,89.7)
PCH_DISP_ON_C: length 34.2
  IN1 w0.14: v1(55.65,76.39) 55.65,76.88 54,78.53 54,81.76 52.91,82.85 52.91,88.28 52.46,88.73 47.29,88.73 47.29,88.72 46.47,88.72 46.47,88.73 46.39,88.73 45.82,89.3 45.8,89.3 45.66,89.44 43.12,89.44 40.18,92.37 v1(40.18,92.65)
  BOTTOM w0.102: v1(40.18,92.65) 40.18,92.88 40.73,93.43 R294.2 39.9,94.4 Q22.1 ; v1(55.65,76.39) 56.44,76.39 57.47,75.36 U7.R53
PCH_DPST_PWM: length 42
  TOP w0.102: v1(63.25,97.2) 63.39,97.2 64.79,95.8 65.25,95.8 65.27,95.78 v1(65.41,95.78) R382.2
  BOTTOM w0.102: Q15.3 33.3,94.99 33.78,95.47 35.17,95.47 R279.1 35.68,96.61 36.01,96.94 41.33,96.94 45.19,100.8 54.03,100.8 54.69,100.14 54.69,98.14 55.27,97.55 57.42,97.55 58.54,98.67 59.26,98.67 59.55,98.96 61.63,98.96 63.25,97.34 v1(63.25,97.2)
PCH_DPST_PWM_C: length 35.4
  IN1 w0.14: v1(54.27,77.52) 53.26,78.53 53.26,81.35 52.06,82.55 52.06,83.9 52.06,84.33 49.82,86.57 43.05,86.57 42.37,87.25 42.37,87.87 41.33,88.92 37.73,88.92 v1(37.26,89.38)
  BOTTOM w0.102: v1(54.27,77.52) 54.83,77.52 55.18,77.17 56.27,77.17 57.6,75.84 58.97,75.84 U7.P52 ; Q15.1 35.33,91.53 35.22,91.42 R290.2 35.22,89.48 35.33,89.38 v1(37.26,89.38)
PCH_EDP_BLON: length 87
  IN1 w0.14: v1(48.73,28.45) 42.13,28.45 39.63,30.95 37.47,30.95 32.66,35.76 32.66,44.04 34.17,45.55 34.17,46.41 35.86,48.09 35.86,52.73 34.36,54.23 33.55,54.23 33.05,54.73 33.05,56.73 33.63,57.32 33.63,58.41 33.02,59.02 33.02,59.41 33.21,59.6 33.21,60.86 32.84,61.23 32.41,61.23 31.42,62.22 31.42,65.44 29.67,67.18 29.67,69.85 28.89,70.64 v1(28.89,71.66)
  IN2 w0.14: v1(28.89,71.66) 27.81,72.73 27.81,77.46 v1(29.64,79.29)
  BOTTOM w0.102: v1(29.64,79.29) 29.66,79.29 29.97,79.6 35.53,79.6 36.03,80.1 37.91,81.98 37.91,84.48 40.1,86.67 R282.1 39.78,87.28 Q17.3 ; v1(48.73,28.45) 48.18,27.9 R71.2
PCH_EDP_BLON_C: length 32.2
  IN1 w0.14: v1(55.02,76.75) 54.77,77 54.04,77 52.66,78.37 52.66,81.17 51.54,82.29 51.54,84.12 49.61,86.05 42.57,86.05 40.82,87.8 v1(40.82,88.36)
  BOTTOM w0.102: v1(40.82,88.36) 40.82,88.69 42.55,90.42 R280.2 41.04,90.53 Q17.1 ; U7.P51 59.48,75.65 59.21,75.65 59.11,75.55 58.85,75.55 58.76,75.64 57.5,75.64 56.26,76.88 55.15,76.88 v1(55.02,76.75)
PCH_SLP_S0#: length 43.7
  TOP w0.108: Q33.1 100.45,91.34 R1029.2 R59.2 99.92,90.33 99.92,88.97 99.26,88.31 99.26,87.48 v1(100.2,86.54) 100.73,86.01 100.73,81.6 101.11,81.23 101.11,79.56 v1(96.72,75.17)
  IN1 w0.102: v1(78.22,81.03) 79.67,81.03 80.57,81.93 82.86,81.93 83.03,81.75 83.57,81.75
  IN1 w0.14: v1(96.72,75.17) 96.72,75.44 94.52,77.64 93.3,77.64 92.63,78.3 89.39,78.3 85.93,81.75 83.57,81.75
  BOTTOM w0.102: v1(78.22,81.03) 78.19,81 U7.D14
PCH_SLP_S0_N: length 93.6
  TOP w0.108: v1(139.82,61.5) 139.64,61.32 137.11,61.32 132.72,65.71 132.72,66.35 131.99,67.07 131.56,67.07 130.87,67.76 123.37,67.76 123.1,67.49 123.1,66.95 122.83,66.68 120.97,66.68 120.12,67.53 120.12,70.53 118.53,72.12 111.76,72.12 109.68,74.21 106.68,74.21 101.32,79.57 101.32,81.32 100.95,81.69 100.95,86.39 100.13,87.21 100.13,89.7 R1029.1 101.23,91.67 R429.1 100.43,92.46 100.43,93.26 99.59,94.1 Q33.3 ; v1(127.55,44.99) 127.55,44.38 127,43.83 R209.1
  IN2 w0.14: v1(139.82,61.5) 139.03,60.7 139.03,56.32 139.15,56.19 139.15,55.62 138.79,55.25 137.96,55.25 136.29,53.58 135.37,53.58 132.34,50.55 131.73,50.55 131.41,50.23 128.86,50.23 126.87,48.24 126.87,45.67 v1(127.55,44.99)
PCH_SLP_S4#: length 9.9
  TOP w0.108: v1(131.86,36.43) 131.42,35.99 131.42,35.38 129.85,33.8 129.85,31.77 129.3,31.22 127.57,31.22 127.46,31.1 U9.18
  BOTTOM w0.108: R247.1 132.23,36.8 v1(131.86,36.43)
PCH_SUSPWRDANCK: length 121.1
  TOP w0.127: v1(147.74,33.49) 147.46,33.21 147.42,33.17 146.84,33.17 R1199.1 R222.1 ; v1(106.05,100.8) 105.84,101.01 104.26,101.01 103.38,100.12 102.31,100.12 100.38,98.19 100.38,95.02 103.78,91.61 v1(103.78,90.93)
  IN1 w0.127: v1(103.78,90.93) 104.48,90.24 113.27,90.24 114.32,89.19 118.85,89.19 121.32,86.72 122.01,86.72 123.9,84.83 124.83,84.83 125.42,84.24 128,84.24 128.77,83.48 129.38,83.48 129.75,83.84 131,83.84 131.31,83.53 139.15,83.53 144.14,78.54 144.14,74.93 147.25,71.82 147.25,71.16 148.56,69.85 149.6,69.85 151.6,67.84 151.6,56.61 152.25,55.97 152.25,39.59 150.42,37.77 149.51,37.77 148.36,36.62 148.36,35.18 148.02,34.84 148.02,33.77 v1(147.74,33.49)
  BOTTOM w0.127: v1(103.78,90.93) 102.9,90.93 102.29,90.33 Q32.3 99.92,90.33 R420.2 ; PR4.1 106.12,100.88 v1(106.05,100.8)
PCH_SUSPWRDANCK_R: length 3.7
  TOP w0.108: U9.87 143.54,34.3 144.36,33.49 144.6,33.49 145.36,32.72 R222.2
PCIE_CLKREQ1_SSD#: length 24.8
  TOP w0.108: v1(101.22,68.14) 101.95,68.14 R224.2
  IN1 w0.14: v1(101.22,68.14) 100.46,67.38 97.35,67.38 96.74,66.77 92.56,66.77 91.58,67.74 84.43,67.74 83.61,66.93 80.01,66.93 v1(79.37,67.57)
  BOTTOM w0.102: U7.AM12 v1(79.37,67.57)
PCIE_CLKREQ2_WLAN#: length 88
  TOP w0.108: v1(99.98,68.62) 100.53,69.17 R225.2 ; v1(132.29,72.32) v1(133.63,72.32) 136.89,72.32 137.36,71.85 139.55,71.85 142.15,74.46 142.15,76.82 143.93,78.6 143.93,79.89 145.04,81 145.04,81.5 145.26,81.72 146.54,81.72 146.85,82.04 Q65.1
  IN2 w0.089: v1(78.03,68.52) 77.83,68.52 77.74,68.61
  IN2 w0.102: 77.74,68.61 77.45,68.9 77.45,71.67 77.7,71.92 80.75,71.92 81.74,72.91 84.15,72.91 84.33,72.74 86.41,72.74 86.56,72.58 88.74,72.58 88.77,72.62
  IN2 w0.14: v1(132.29,72.32) 130.81,73.8 129,73.8 127.98,74.82 126.64,74.82 124.61,72.78 122.9,72.78 122.31,72.19 121.78,72.19 121.62,72.02 119.36,72.02 119.06,71.73 114.83,71.73 113.74,70.64 113,70.64 111.89,69.53 111.33,68.97 100.32,68.97 v1(99.98,68.62) 99.95,68.62 96.69,71.89 95.62,71.89 94.37,71.89 93.71,72.55 91.26,72.55 91.19,72.62 88.77,72.62
  BOTTOM w0.102: v1(78.03,68.52) 78.03,68.49 U7.AK14
PCIE_CLKREQ2_WLAN#_R: length 24.2
  TOP w0.108: v1(151.72,93.08) 149.76,93.08 148.7,92.02 148.7,85.87 v1(148.08,85.26) R598.2 148.08,83.83 146.04,83.83 145.83,84.04 Q65.3
  BOTTOM w0.108: CN5.53 156.79,98.75 156.27,98.23 156.27,97.12 152.46,93.31 151.94,93.31 v1(151.72,93.08)
PCIE_CLKREQ3_LAN#: length 23.3
  IN1 w0.14: v1(77.98,67.55) 78.87,66.67 83.97,66.67 84.66,67.35 91.54,67.35 92.55,66.35 94.65,66.35 95.33,65.67 95.45,65.67 97,64.13 v1(97.36,64.13)
  BOTTOM w0.102: U7.AM14 77.98,67.47 v1(77.98,67.55)
  BOTTOM w0.108: v1(97.36,64.13) 96.22,64.13 R223.2
PCIE_RXN2_WLAN: length 112.8
  IN2 w0.102: 76.03,83.18 76.03,83.15 76,83.12 76,82.11 75.13,81.24 75.13,80.81 74.89,80.57 74.51,80.57 74.37,80.43 v1(74.37,80.25)
  IN2 w0.14: v1(143.64,82.22) 143.36,82.49 142.63,82.49 140.73,80.59 133.28,80.59 132.18,79.49 127.88,79.49 127.29,80.09 123.23,80.09 121.32,81.99 120.77,81.99 119.94,82.82 118.11,82.82 116.13,84.81 102.57,84.81 102.08,85.3 101.28,85.3 101.01,85.58 100.26,85.58 99.7,86.14 98.58,86.14 94.8,89.92 91.77,89.92 89.77,91.91 87.05,91.91 85.87,90.73 85.38,90.73 84.71,90.06 82.93,90.06 80.61,87.75 77.85,87.75 76.51,86.41 75.75,86.41 75.32,85.99 75.32,84.1 76.03,83.4 76.03,83.18
  BOTTOM w0.102: CN5.43 157.29,101.25 157.22,101.32 156.8,101.32 154.84,99.36 154.84,97.88 153.19,96.23 150.4,96.23 147.01,92.84 147.01,84.9 144.64,82.52 143.94,82.52 v1(143.64,82.22) ; U7.F22 73.84,80.02 74.08,80.25 v1(74.37,80.25)
PCIE_RXP2_WLAN: length 112.8
  IN2 w0.102: v1(74.35,80.94) 74.52,80.77 74.8,80.77 74.93,80.9 74.93,81.33 75.79,82.19 75.79,83.12 75.76,83.15 75.76,83.18
  IN2 w0.14: 75.76,83.18 75.76,83.29 75.06,83.99 75.06,86.1 75.64,86.68 76.4,86.68 77.74,88.01 80.5,88.01 82.82,90.33 84.6,90.33 85.27,91 85.76,91 86.94,92.18 89.89,92.18 91.88,90.19 94.91,90.19 98.69,86.41 99.81,86.41 100.37,85.84 101.12,85.84 101.39,85.57 102.19,85.57 102.68,85.07 116.24,85.07 118.22,83.09 120.05,83.09 120.88,82.26 121.43,82.26 123.34,80.36 127.4,80.36 127.99,79.76 132.07,79.76 133.16,80.86 140.62,80.86 142.52,82.76 143.37,82.76 v1(143.64,83.03)
  BOTTOM w0.102: v1(74.35,80.94) 74.04,80.64 U7.D22 ; v1(143.64,83.03) 143.94,82.72 144.55,82.72 146.81,84.98 146.81,92.93 150.32,96.43 153.1,96.43 154.64,97.97 154.64,99.44 156.72,101.52 157.08,101.52 157.31,101.75 CN5.41
PCIE_TXN2_WLAN: length 126.6
  IN2 w0.14: v1(64.76,86.32) 64.76,86.17 64.63,86.05 64.37,86.05 64.26,86.15 64.26,90.57 68.44,94.75 71.04,94.75 72.07,93.71 77.41,93.71 79.27,95.57 83.24,95.57 83.62,95.19 90.15,95.19 92.94,92.4 96.34,92.4 98.73,90.01 99.42,90.01 100.87,88.56 104.37,88.56 105.33,87.59 108.31,87.59 108.55,87.84 117.08,87.84 119.21,85.7 120.97,85.7 124.22,82.46 128.25,82.46 128.86,81.85 131.2,81.85 132.3,82.95 138.89,82.95 142.42,86.48 143.46,86.48 146.31,89.33 146.31,92.68 150.61,96.98 150.61,100.23 155.58,105.2 156.67,105.2 156.93,104.93 156.93,104.6 156.79,104.46 v1(156.57,104.46)
  BOTTOM w0.102: CN5.37 157.43,102.75 156.82,103.36 156.82,103.85 156.97,104 156.97,104.37 156.88,104.46 v1(156.57,104.46) ; C40.1 66.51,86.21 66.36,86.06 66.02,86.06 65.83,85.87 65.51,85.87 65.36,86.02 64.87,86.02 64.76,86.13 v1(64.76,86.32)
PCIE_TXN2_WLAN_C: length 8.3
  BOTTOM w0.102: C40.2 68.45,85.38 68.45,85.23 69.44,84.24 70.77,84.24 72.09,82.92 72.09,82.15 72.19,82.06 72.19,81.8 71.88,81.5 U7.C26
PCIE_TXP2_WLAN: length 126.6
  IN2 w0.14: v1(157.38,104.46) 157.2,104.64 157.2,105.04 156.78,105.46 155.47,105.46 150.34,100.34 150.34,97.09 146.04,92.79 146.04,89.44 143.35,86.74 142.31,86.74 138.78,83.22 132.19,83.22 131.09,82.12 128.97,82.12 128.36,82.73 124.33,82.73 121.09,85.97 119.32,85.97 117.19,88.1 108.44,88.1 108.2,87.86 105.45,87.86 104.48,88.83 100.98,88.83 99.53,90.27 98.84,90.27 96.45,92.66 93.05,92.66 90.26,95.46 83.73,95.46 83.35,95.84 79.16,95.84 77.3,93.98 72.18,93.98 71.15,95.01 68.33,95.01 64,90.68 64,86.04 64.25,85.78 64.54,85.78 v1(64.76,85.56)
  BOTTOM w0.102: CN5.35 157.22,103.25 157.02,103.44 157.02,103.77 157.17,103.92 157.17,104.26 v1(157.38,104.46) ; v1(64.76,85.56) 65.01,85.82 65.27,85.82 65.42,85.66 65.91,85.66 66.1,85.85 66.35,85.85 66.53,85.67 C39.1
PCIE_TXP2_WLAN_C: length 8.3
  BOTTOM w0.102: U7.B26 71.89,81.79 71.81,81.71 71.67,81.71 71.54,81.85 71.54,82.01 71.75,82.22 71.82,82.22 71.89,82.29 71.89,82.84 70.69,84.04 69.36,84.04 68.25,85.15 68.25,85.3 67.5,86.05 67.39,86.05 67.31,85.98 C39.2
PCIE_WAKE#_R: length 26.5
  TOP w0.108: v1(152.83,92.83) 152.3,92.29 150.45,92.29 148.91,90.76 148.91,80.67 R331.1 147.11,79.84 146.85,79.57 Q25.1
  BOTTOM w0.108: v1(152.83,92.83) 152.83,93.38 156.48,97.03 156.48,97.98 156.75,98.25 CN5.55
PD#: length 24.2
  TOP w0.108: R105.2 26.24,19.65 v1(26.05,19.84) 25.98,19.9 24.89,19.9 24.77,20.03 D10.2 24.77,21.33 24.65,21.45 23.1,21.45 22.99,21.34 D9.2 22.99,20.13 22.4,19.54 20.53,19.54 17.5,16.5 17.5,14.67 16.69,13.86 15.57,13.86 14.99,14.44 14.43,14.44 13.87,13.88 12.22,13.88 12.06,14.04 10.47,14.04 10.39,14.13 U4.47
PGANG: length 2.9
  BOTTOM w0.108: U35.23 27.58,67.62 v1(27.04,68.16) R1120.2
PHASE_CORE: length 8
  TOP w0.508: PR184.2 40.17,75.06 v2(39.63,74.51)
  IN2 w0.762: v2(39.63,74.51) 41.45,72.69 41.45,70.37 42.55,69.28 v2(42.55,69.1)
  vias: v1(41.86,68.85)
PHASE_VGG: length 11.6
  TOP w0.203: PU6.23 121.94,55.31 121.65,55.6 v2(121.65,55.9)
  TOP w0.508: PC68.1 120.13,56.62 120.62,56.13 121.41,56.13 v2(121.65,55.9)
  IN1 w0.762: v2(125.73,62.7) 121.65,58.62 v2(121.65,55.9)
  vias: v1(126.09,61.81)
PLL_1P24_PWR: length 29.5
  TOP w0.381: v1(70.26,72.07) 70.35,71.98 C172.1 ; v1(69.5,74.42) 69.59,74.51 C180.2 ; C152.1 66.19,76.14 v1(65.62,76.14)
  TOP w0.508: v1(55.68,81.37) 54.86,80.55 R313.2
  IN1 w0.508: v1(69.5,74.42) 68.9,74.42 67.19,76.14 v1(65.62,76.14) 65.62,75.98 64.56,74.92 62.18,74.92 61.76,74.5 61.15,74.5 60.58,75.07 60.58,75.63 60.25,75.96 57.2,75.96 56.76,76.4 56.76,77.34 55.11,79 55.11,80.8 v1(55.68,81.37)
  IN2 w0.508: v1(70.26,72.07) 70.26,73.85 69.69,74.42 v1(69.5,74.42)
  BOTTOM w0.254: U7.P38 v1(65.62,76.14) ; v1(70.26,72.07) U7.AC30 ; v1(69.5,74.42) U7.V30
