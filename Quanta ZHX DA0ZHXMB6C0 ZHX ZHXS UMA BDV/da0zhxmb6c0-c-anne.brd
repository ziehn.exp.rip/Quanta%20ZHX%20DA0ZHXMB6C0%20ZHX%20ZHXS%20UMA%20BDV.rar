# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.8V_S5 on BOTTOM (solid shape): outline of 287 points within 87.71,64.48 99.96,76.45
+1.8V_S5 on VCC (solid shape): outline of 1161 points within 85.09,96.99 101.6,108.78
+1.8V_S5 on IN1 (solid shape): 95.15,68.88 95.15,68.48 94.94,68.4 94.79,68.23 92.75,68.23 92.09,68.89 91.73,68.89 91.59,69.03 91.59,69.48 91.75,69.64 94.39,69.64
+1.8V_S5 on IN1 (solid shape): outline of 420 points within 95.9,103.06 117.68,112.08
+1.15V on TOP (solid shape): 127.69,76.29 127.69,75.17 127.72,75.14 127.72,75.02 127.76,74.97 127.76,73.9 127.6,73.74 126.79,73.74 126.6,73.92 126.6,75.1 126.55,75.15 126.55,75.23 126.28,75.5 126.28,76.4 126.51,76.63 127.34,76.63
+1.15V on TOP (solid shape): 109.02,66.89 109.04,66.89 109.11,66.82 109.11,65.9 108.53,65.32 106.61,65.32 106.5,65.43 102.65,65.43 102.54,65.32 102.41,65.32 102.01,64.91 101.56,64.91 101.42,64.94 101.3,64.92 101.29,64.91 100.48,64.91 100.1,64.53 98.61,64.53 98.53,64.46 97.66,64.46 97.64,64.48 97.64,65.32 97.65,65.35 97.68,65.37 97.9,65.51 97.97,65.76 97.98,65.78 97.99,65.8 98.05,65.85 98.56,65.85 98.64,65.8 98.64,65.7 98.96,65.16 99.28,65.7 99.28,65.8 99.36,65.85 99.43,65.85 99.46,65.84 99.48,65.8 100.51,65.8 100.52,65.84 100.56,65.85 100.79,65.85 100.83,65.84 100.84,65.8 101.87,65.8 101.87,65.92 102.24,66.28 107.24,66.28 108,67.04 108.15,67.04 108.16,67.03 108.31,66.99 108.46,67.01 108.5,67.03 108.53,67.05 108.87,67.05
+1.15V on BOTTOM (solid shape): 115.7,106.06 115.7,105.5 115.83,105.37 115.83,104.89 115.41,104.48 114.8,104.48 114.66,104.34 114.66,103.74 114.66,103.74 114.63,103.7 114.47,103.7 114.47,104.63 114.63,104.79 114.63,106.16 114.67,106.2 115.56,106.2
+1.15V on IN2 (solid shape): 110.29,67.73 110.29,67 110.27,66.98 110.1,66.88 110,66.71 109.99,66.7 109.91,66.61 109.91,66.21 109.47,65.77 108.67,65.77 108.03,66.4 108.03,66.76 108.23,66.95 108.25,66.96 108.27,66.96 108.71,67.25 108.47,67.72 108.42,67.77 108.41,67.84 108.42,67.99 108.37,68.14 108.36,68.24 108.45,68.29 109.73,68.29
+1.15V on IN2 (solid shape): 128.6,73.6 128.6,72.53 128.22,72.15 126.5,72.15 126.48,72.17 126.42,72.2 126.36,72.21 126.3,72.22 126.23,72.22 126.17,72.22 126.11,72.2 126.05,72.18 126.01,72.15 125.93,72.15 125.3,72.79 125.3,73.18 125.48,73.36 126.86,73.36 126.86,73.3 126.87,73.24 126.89,73.19 126.91,73.14 126.94,73.09 126.98,73.05 127.02,73.01 127.07,72.98 127.12,72.96 127.17,72.94 127.23,72.93 127.28,72.93 127.34,72.94 127.39,72.96 127.44,72.98 127.49,73.01 127.53,73.05 127.57,73.09 127.6,73.14 127.62,73.19 127.64,73.24 127.65,73.3 127.65,73.36 127.64,73.41 127.62,73.47 127.6,73.52 127.57,73.56 127.53,73.61 127.49,73.64 127.44,73.67 127.39,73.7 127.34,73.71 127.28,73.72 127.23,73.72 127.17,73.71 127.12,73.7 127.07,73.67 127.02,73.64 126.98,73.61 126.94,73.56 126.91,73.52 126.89,73.47 126.87,73.41 126.86,73.36 125.48,73.36 126.42,74.3 127.9,74.3
+1.24VS5 on TOP (solid shape): outline of 160 points within 51.92,69.71 59.87,83.91
+1.24VS5 on BOTTOM (solid shape): 114.5,105.79 114.5,104.83 114.27,104.61 114.27,104.34 114.27,103.74 114.22,103.68 114.09,103.68 114.07,103.7 114.07,104.4 113.98,104.5 113.98,104.71 114.06,104.89 114.04,105.08 114.04,105.09 114.04,105.13 113.86,105.31 113.39,105.31 113.32,105.39 113.32,106.1 113.34,106.13 114.16,106.13
+1.35VSUS on TOP (solid shape): 83.42,60.57 83.42,59.71 83.2,59.5 82.4,59.5 82.14,59.75 82.14,60.01 82.15,60.03 82.17,60.05 82.38,60.38 82.17,60.7 82.15,60.72 82.14,60.75 82.14,61.05 82.31,61.22 82.77,61.22
+1.35VSUS on TOP (solid shape): outline of 84 points within 62.59,46.53 66.41,48.63
+1.35VSUS on TOP (solid shape): outline of 3079 points within 75.31,34.39 108.21,66.06
+1.35VSUS on TOP (solid shape): outline of 3979 points within 35,30.62 68.04,66
+1.35VSUS on TOP (solid shape): outline of 4102 points within 58.02,33.47 86.76,54.5
+1.35VSUS on BOTTOM (solid shape): 77.51,52.73 78.73,52.73 78.94,52.52 78.93,52.44 78.93,52.21 78.93,51.98 78.64,51.98 78.61,52.01 78.55,52.05 78.47,52.07 78.45,52.07 78.38,52.1 78.35,52.17 78.08,52.49 77.72,52.3 77.71,52.29 77.33,51.91 77.33,51.88 77.33,51.87 77.33,51.62 77.5,51.45 77.51,51.45 77.6,51.36 77.6,51.36 77.63,51.32 77.64,51.27 77.59,51.24 77,51.24 76.99,51.22 76.93,51.21 76.9,51.25 76.9,51.58 76.73,51.74 76.73,52.85 76.78,52.9 77.19,52.9 77.23,52.9 77.27,52.92 77.31,52.93
+1.35VSUS on BOTTOM (solid shape): outline of 182 points within 97.64,44.99 101.92,50.19
+1.35VSUS on BOTTOM (solid shape): outline of 10814 points within 33.96,30.08 109.04,60.01
+1.35VSUS on IN1 (solid shape): outline of 1743 points within 37.82,32.99 79.44,46.29
+1.35VSUS on IN2 (solid shape): outline of 423 points within 80.72,49.84 85.44,61.59
+1.35VSUS on IN2 (solid shape): outline of 1936 points within 37.49,30.62 103.66,46.42
+3V on TOP (solid shape): 121.64,72.58 121.64,71.77 121.44,71.57 119.64,71.57 119.46,71.75 119.46,73.04 119.69,73.27 120.96,73.27
+3V on TOP (solid shape): 148.72,106.37 148.72,105.76 148.62,105.66 148.62,103.88 148.13,103.39 146.84,103.39 146.46,103.77 146.46,105.58 146.82,105.93 147.24,105.93 147.6,105.87 147.83,106.14 147.83,106.16 148.17,106.49 148.59,106.49
+3V on TOP (solid shape): 145.77,58.08 145.77,57.63 145.75,57.6 145.74,57.59 145.52,57.09 146.05,56.95 146.1,56.95 146.12,56.9 146.12,56.86 146.19,56.71 146.33,56.65 146.62,56.65 146.62,56.64 147.4,56.64 147.79,56.25 148.16,56.25 148.24,56.17 148.24,53.92 147.97,53.65 144.54,53.65 143.09,55.1 143.09,57.91 143.54,58.36 145.49,58.36
+3V on TOP (solid shape): 136.16,61.14 136.16,60.14 135.79,59.77 131.88,59.77 131.67,59.98 131.67,60.26 131.55,60.39 131.27,60.39 130.87,60.79 130.87,62.79 131.57,62.79 131.57,62.74 131.58,62.69 131.6,62.64 131.62,62.59 131.65,62.54 131.69,62.5 131.73,62.47 131.78,62.44 131.83,62.42 131.88,62.41 131.94,62.4 131.99,62.41 132.04,62.42 132.09,62.44 132.14,62.47 132.18,62.5 132.22,62.54 132.25,62.59 132.27,62.64 132.29,62.69 132.3,62.74 132.3,62.79 132.29,62.85 132.27,62.9 132.25,62.95 132.22,62.99 132.18,63.03 132.14,63.07 132.09,63.09 132.04,63.11 131.99,63.13 131.94,63.13 131.88,63.13 131.83,63.11 131.78,63.09 131.73,63.07 131.69,63.03 131.65,62.99 131.62,62.95 131.6,62.9 131.58,62.85 131.57,62.79 130.87,62.79 130.87,63.85 131.39,64.36 132.94,64.36
+3V on BOTTOM (solid shape): 126.67,100.55 126.67,97.95 126.57,97.85 126.2,97.85 126.11,97.94 126.11,98.14 125.93,98.31 125.17,98.31 125.12,98.36 125.12,100.09 125.73,100.7 126.52,100.7
+3V on BOTTOM (solid shape): 46.79,93.44 46.79,92.6 46.74,92.55 45.34,92.55 45.21,92.42 45.21,91.35 45.39,91.18 46.76,91.18 46.79,91.15 46.79,90.57 46.75,90.54 45.77,90.54 45.7,90.46 45.7,89.5 45.34,89.14 44.47,89.14 43.64,89.98 43.64,93.36 44.07,93.79 46.43,93.79
+3V on VCC (solid shape): outline of 9774 points within 28.07,38.7 131.7,102.76
+3V on IN1 (solid shape): outline of 2977 points within 43.45,71.49 121.72,96.6
+3V on IN2 (solid shape): outline of 1758 points within 124.56,89.88 148.78,107.02
+3V_EMMC on TOP (solid shape): 116.71,78.58 116.71,77.82 116.69,77.8 116.46,77.7 116.35,77.47 116.35,77.45 116.31,77.41 116.31,77.19 116.29,77.16 116.28,77.16 116.21,77.08 116.18,76.98 116.18,76.68 116.23,76.54 116.34,76.47 116.36,76.47 116.59,76.24 116.6,76.22 116.61,76.2 116.71,75.91 117,75.8 117.01,75.8 117.03,75.8 117.1,75.73 117.7,75.73 118.31,75.12 118.31,74.51 118.37,74.46 118.37,74.45 118.44,74.36 118.53,74.29 118.54,74.29 118.59,74.23 118.95,74.23 119.28,73.9 119.28,72.56 119.15,72.43 118.03,72.43 117.58,72.89 117.58,74.69 117.22,75.05 116.79,75.05 116.61,75.23 116.51,75.33 116.36,75.33 116.23,75.33 116.2,75.3 116.1,75.23 116.03,75.13 116.03,75.13 115.9,75 115.9,74.89 115.72,74.72 115.44,74.72 115.32,74.84 115.32,75.19 115.33,75.21 115.35,75.22 115.49,75.32 115.57,75.46 115.57,75.48 115.67,75.58 115.67,76.65 115.6,76.72 115.59,76.74 115.59,76.77 115.6,76.89 115.58,77.02 115.57,77.03 115.57,77.82 115.95,78.2 115.95,78.58 116.08,78.7 116.59,78.7
+3V_MINI1_VDD on TOP (solid shape): 154.74,94.2 160.15,94.2 160.53,93.82 160.83,93.82 160.91,93.74 160.91,93.2 160.67,92.96 153.28,92.96 153.19,93.06 153.19,94.15 153.49,94.45 154.48,94.45
+3V_MINI1_VDD on TOP (solid shape): 159.09,112.33 160.37,112.33 160.91,111.79 160.91,111.2 160.82,111.11 160.55,111.11 160.07,110.63 159.61,110.63 159.59,110.6 159.56,110.58 159.54,110.58 159.28,110.33 159.28,107.53 159.2,107.45 159.2,106.94 159.01,106.75 156.82,106.75 156.67,106.9 156.67,107.15 156.82,107.31 157.1,107.31 157.28,107.48 157.28,109.26 157.81,109.79 157.81,111.7 158.45,112.33 159.09,112.33
+3V_MINI1_VDD on TOP (solid shape): 152.66,105.63 152.66,103.19 152.38,102.91 150.22,102.91 149.73,103.4 148.86,103.4 148.74,103.53 148.74,104.7 150.47,104.7 150.47,104.64 150.47,104.59 150.49,104.54 150.51,104.49 150.54,104.44 150.58,104.4 150.62,104.37 150.67,104.34 150.72,104.32 150.77,104.31 150.83,104.31 150.88,104.31 150.93,104.32 150.99,104.34 151.03,104.37 151.07,104.4 151.11,104.44 151.14,104.49 151.17,104.54 151.18,104.59 151.19,104.64 151.19,104.7 151.18,104.75 151.17,104.8 151.14,104.85 151.11,104.9 151.07,104.94 151.03,104.97 150.99,105 150.93,105.02 150.88,105.03 150.83,105.03 150.77,105.03 150.72,105.02 150.67,105 150.62,104.97 150.58,104.94 150.54,104.9 150.51,104.85 150.49,104.8 150.47,104.75 150.47,104.7 148.74,104.7 148.74,105.5 149.03,105.79 152.49,105.79
+3V_MINI1_VDD on IN1 (solid shape): outline of 1207 points within 148.43,92.04 160.94,112.16
+3V_RTC_R on BOTTOM (solid shape): 139.62,39.64 139.62,37.89 138.96,37.23 138.44,37.23 138.41,37.19 138.32,37.19 138.23,37.1 137.17,37.1 137.04,37.23 136.98,37.28 136.4,37.86 135.97,37.86 135.61,38.22 135.61,38.37 137.54,38.37 137.54,38.32 137.55,38.26 137.57,38.21 137.6,38.17 137.63,38.12 137.67,38.09 137.72,38.06 137.77,38.03 137.82,38.02 137.87,38.01 137.93,38.01 137.98,38.02 138.03,38.03 138.08,38.06 138.13,38.09 138.17,38.12 138.2,38.17 138.23,38.21 138.25,38.26 138.26,38.32 138.26,38.37 138.26,38.42 138.25,38.48 138.23,38.53 138.2,38.57 138.17,38.62 138.13,38.65 138.08,38.68 138.03,38.71 137.98,38.72 137.93,38.73 137.87,38.73 137.82,38.72 137.77,38.71 137.72,38.68 137.67,38.65 137.63,38.62 137.6,38.57 137.57,38.53 137.55,38.48 137.54,38.42 137.54,38.37 135.61,38.37 135.61,39.59 135.69,39.67 136.75,39.67 136.91,39.82 139.45,39.82
+3V_S5 on BOTTOM (solid shape): 93.88,84.09 94.22,84.09 94.28,84.05 94.35,84.04 94.65,84.04 94.73,84.05 94.79,84.09 95.01,84.09 95.15,83.95 95.15,82.77 94.7,82.31 93.79,82.31 93.39,82.72 93.39,83.72 93.39,83.73 93.39,84.04 93.41,84.07 93.44,84.09 93.88,84.09
+3V_SRC on BOTTOM (solid shape): 126.9,96.23 126.9,93.07 127.43,92.55 127.43,87.3 126.12,85.99 124.63,85.99 124.56,85.92 124.56,85.72 124.46,85.61 123.91,85.61 123.64,85.88 123.64,91.71 124,92.07 124.66,92.07 124.84,92.24 124.84,92.41 124.86,92.45 124.89,92.47 124.97,92.47 124.97,96.44 124.95,96.44 124.9,96.47 124.91,96.53 124.97,96.59 126.54,96.59
+3V_SSD on TOP (solid shape): 153.53,57.39 155.32,57.39 155.53,57.6 156.34,57.6 156.44,57.5 156.44,56.94 156.24,56.73 155.93,56.73 155.49,56.3 155.49,54.82 155.4,54.73 148.56,54.73 148.48,54.81 148.48,56.1 148.64,56.25 148.8,56.25 148.84,56.29 151.94,56.29 152.15,56.51 152.15,57.47 152.37,57.69 153.24,57.69
+3V_USB on TOP (solid shape): 32.51,63.82 32.79,63.54 32.8,63.53 32.85,63.44 32.94,63.39 32.95,63.38 33.07,63.26 33.34,63.26 33.56,63.04 33.56,62.61 33.46,62.51 32.56,62.51 32.22,62.17 32.22,61.26 32.09,61.13 31.13,61.13 31.11,61.11 31.09,61.11 30.84,61 30.73,60.75 30.73,60.73 30.28,60.28 30.26,60.27 30.25,60.27 29.97,60.17 29.87,59.89 29.86,59.87 29.85,59.85 29.69,59.69 29.69,59.68 29.68,59.65 29.64,59.63 28.41,59.63 28.33,59.68 28.32,59.78 27.99,60.29 27.66,59.78 27.66,59.68 27.57,59.63 27.15,59.63 26.98,59.81 26.98,60.52 26.9,60.59 26.9,61.11 26.95,61.16 27.12,61.16 27.13,61.17 30.24,61.17 31.48,62.41 31.48,63.7 31.62,63.85 32.51,63.85
+3VPCU on TOP (solid shape): 5.89,4.84 5.89,4.13 5.77,4 4.2,4 4.2,5 5.74,5
+3VPCU on TOP (solid shape): 121.85,32.32 121.94,32.27 121.94,32.17 122.04,31.7 122.53,31.76 122.61,31.8 122.68,31.76 123.03,31.64 123.3,31.87 123.35,31.92 123.72,31.92 123.78,31.87 123.78,30.47 123.25,29.94 123.23,29.93 123.21,29.93 122.91,29.82 122.81,29.53 122.8,29.51 122.79,29.49 122.61,29.3 121.69,29.3 121.26,29.74 121.26,30.44 121.03,30.66 121.03,31.44 121.04,31.46 121.05,31.47 121.15,31.63 121.16,31.83 121.17,31.86 121.31,31.99 121.31,32.27 121.33,32.31 121.36,32.32
+3VPCU on BOTTOM (solid shape): 124.89,100.41 124.89,97.35 124.56,97.02 124.56,92.5 124.44,92.37 119.51,92.37 119.33,92.55 119.33,96.39 119.3,96.42 119.3,96.65 119.37,96.74 119.48,96.72 119.94,96.65 120.17,97.06 120.17,97.09 120.16,97.13 120.18,97.22 120.26,97.26 120.27,97.26 121.18,98.17 121.18,99.71 122.13,100.66 124.64,100.66
+3VPCU_EC on BOTTOM (solid shape): 132.03,39.84 132.03,39.03 131.7,38.7 131.68,38.66 131.57,38.4 131.68,38.13 131.7,38.1 131.7,38.04 131.28,37.62 131.24,37.6 131.21,37.62 130.73,38.1 130.71,38.13 130.73,38.16 130.75,38.6 130.33,38.74 130.24,38.76 130.2,38.84 130.2,39.72 130.4,39.92 131.95,39.92
+3VPCU_EC_MAIN on TOP (solid shape): 141.67,48.91 141.67,47.22 143.1,45.79 143.1,45.61 143.1,45.61 143.1,43.96 142.45,43.31 141.7,43.31 141.53,43.48 141.53,44.35 142.05,44.87 142.11,45.31 141.71,45.48 141.69,45.48 141.67,45.49 141.57,45.58 141.4,45.58 141.02,45.96 140.63,45.96 140.47,45.81 138.21,45.81 138.13,45.86 138.13,45.96 138.15,46.01 138.15,46.06 138.15,46.34 138.13,46.44 138.04,46.54 138.03,46.56 138.03,47.15 137.68,47.5 137.67,47.53 137.05,47.8 137.32,47.18 137.34,47.17 137.35,47.16 137.56,46.96 137.56,46.55 137.55,46.53 137.54,46.52 137.46,46.44 137.44,46.34 137.44,46.06 137.46,45.97 137.52,45.9 137.53,45.89 137.54,45.87 137.54,45.83 137.51,45.81 137.5,45.81 137.5,45.71 137.47,45.67 137.44,45.61 136.88,45.05 136.8,45.02 136.73,45.06 136.55,45.18 136.33,45.18 136.24,45.2 136.2,45.28 136.2,49.04 136.58,49.42 141.16,49.42
+5V on TOP (solid shape): 12.19,28.16 12.19,27.04 12.02,26.86 10.69,26.86 10.62,26.94 10.62,28.24 10.67,28.29 12.07,28.29
+5V on TOP (solid shape): 16,89.14 16,86.71 15.88,86.58 13.92,86.58 13.64,86.86 13.64,89.3 14.17,89.83 15.32,89.83
+5V on TOP (solid shape): 84.58,105.21 84.58,103.47 84.41,103.29 82.09,103.29 81.54,103.85 81.54,105.25 81.76,105.47 84.33,105.47
+5V on TOP (solid shape): 151.13,63.41 151.13,62.3 151.15,62.28 151.15,61.03 150.86,60.74 149.82,60.74 149.57,60.99 148.74,60.99 148.46,61.26 148.46,63.61 148.6,63.74 150.8,63.74
+5V on TOP (solid shape): 14.61,13.55 14.61,11.75 14.23,11.37 12.35,11.37 11.89,11.83 11.89,12.39 11.76,12.51 11.76,13.43 12.04,13.71 13.92,13.71 13.97,13.76 14.4,13.76
+5V on TOP (solid shape): 118.24,113.31 118.24,111.92 116.94,110.62 115.22,110.62 115.2,110.64 115.2,112.05 115.21,112.06 116.26,112.63 117,113.56 117.02,113.58 117.04,113.59 117.97,113.59
+5V on BOTTOM (solid shape): 118.24,113.38 118.24,111.83 118.11,111.7 115.83,111.7 115.65,111.88 115.65,112.13 115.87,112.36 116.44,112.81 116.89,113.38 117.04,113.53 118.09,113.53
+5V on VCC (solid shape): outline of 140 points within 14.73,41.49 20.7,54.96
+5V on VCC (solid shape): outline of 3422 points within 5.03,60.8 151.51,113.97
+5V on IN1 (solid shape): 15.69,90.14 15.69,87.43 15.31,87.05 13.93,87.05 13.54,87.44 13.54,89.96 14.02,90.44 15.39,90.44
+5V on IN1 (solid shape): 16.73,51.89 16.96,51.78 17.2,51.82 17.3,51.82 17.35,51.73 17.35,51.37 17.17,51.2 15.65,51.2 15.63,51.21 15.62,51.23 15.29,51.45 14.94,51.27 14.76,51.27 14.05,51.98 14.05,53.26 15.36,53.26
+5V on IN1 (solid shape): outline of 907 points within 10.78,11.58 20.75,43.32
+5V_HDD on TOP (solid shape): 151.13,67.79 151.13,65.69 151.4,65.42 154.46,65.42 154.88,65.84 154.88,66.15 155.22,66.49 155.53,66.49 155.53,63.25 155.37,63.1 151.72,63.1 150.89,63.92 148.12,63.92 147.69,64.35 145.71,64.35 145.62,64.41 145.64,64.52 145.38,65.14 145.12,64.52 145.14,64.41 145.05,64.35 144.84,64.35 143.02,62.53 139.42,62.53 138.99,62.09 137.61,62.09 137.19,62.51 137.19,66.18 137.91,66.91 140.47,66.91 140.54,66.99 140.58,66.99 141.58,67.99 150.93,67.99
+5V_HDD on BOTTOM (solid shape): 140.51,64.8 140.51,62.86 140.27,62.62 139.44,62.62 138.91,62.09 137.84,62.09 137.39,62.53 137.39,65.04 137.58,65.23 140.09,65.23
+5V_S5 on TOP (solid shape): 157.1,108.93 157.1,107.64 156.97,107.51 156.08,107.51 155.93,107.66 155.93,109.06 156.13,109.26 156.77,109.26
+5V_S5 on TOP (solid shape): 110.15,111.92 110.18,111.9 110.2,111.87 110.2,109.21 110.08,109.1 109.36,109.1 109.23,108.97 109.23,108.9 109.08,108.75 108.29,108.75 108.01,109.03 108.01,109.14 107.99,109.18 107.99,109.19 107.97,109.25 107.92,109.31 107.86,109.35 107.78,109.37 107.5,109.37 107.44,109.36 107.38,109.33 107.37,109.32 107.17,109.32 106.8,109.69 106.8,109.71 106.8,109.72 106.7,110.02 106.41,110.13 106.3,110.12 106.19,110.08 106.16,110.07 106.13,110.08 105.88,110.33 105.88,111.87 105.9,111.9 105.93,111.92
+5V_S5 on BOTTOM (solid shape): 21.59,56.86 21.59,55.9 21.23,55.54 18.22,55.54 17.78,55.98 17.78,56.66 18.37,57.24 21.21,57.24
+5V_S5 on BOTTOM (solid shape): 157.1,108.85 157.1,107.61 156.84,107.35 156.83,107.35 156.67,107.26 156.57,107.09 156.57,107.08 156.41,106.92 156.41,106.11 156.41,106.04 156.41,105.9 156.26,105.75 155.07,105.75 154.77,106.06 154.77,108.6 154.97,108.8 155.99,108.8 156.32,109.13 156.83,109.13
+5V_S5 on VCC (solid shape): outline of 1295 points within 139.32,98.39 157.23,112.47
+5V_S5 on VCC (solid shape): outline of 11098 points within 17.53,27.78 137.03,109.85
+5V_S5 on IN2 (solid shape): outline of 338 points within 130.93,99.71 143,112.47
+5VA on TOP (solid shape): 9.83,28.26 9.83,26.87 9.78,26.82 8.33,26.82 8.17,26.98 8.17,28.21 8.3,28.34 9.74,28.34
+5VA on TOP (solid shape): 5.33,24.56 5.33,21.2 4.86,20.73 4.86,19.56 4.85,19.55 4.19,19.55 4.06,19.68 4.06,21.43 3.89,21.61 3.53,21.61 3.44,21.7 3.44,23.24 3.94,23.74 3.94,24.76 4.04,24.86 5.03,24.86
+5VA on BOTTOM (solid shape): 9.07,27.98 9.07,26.76 5.28,22.97 5.28,22.09 5.13,21.94 4.19,21.94 3.98,22.15 3.98,24.27 8.1,28.39 8.66,28.39
+5VPCU on TOP (solid shape): 121.92,113.4 121.92,107.8 121.67,107.56 120.28,107.56 120.2,107.59 120.18,107.66 119.95,108 119.56,107.92 119.2,107.56 111.01,107.56 110.57,107.99 110.57,111.53 110.7,111.66 111.37,111.66 111.51,111.52 111.51,111.37 111.5,111.24 111.52,111.1 111.52,111.04 111.59,110.97 111.87,110.77 112.21,110.8 112.42,110.8 112.43,110.8 112.46,110.8 112.71,110.76 112.95,110.83 113.21,110.77 113.37,110.75 113.67,110.45 117.24,110.45 118.46,111.67 118.46,113.65 118.7,113.88 121.44,113.88
+5VPCU on BOTTOM (solid shape): 121.84,113.71 121.84,112.26 121.83,112.23 121.79,112.21 121.79,108.34 121.57,108.12 119.46,108.12 119,107.66 113.06,107.66 112.93,107.53 112.93,106.89 112.89,106.81 112.8,106.79 112.45,106.74 112.27,106.44 112.37,106.13 112.65,105.99 112.67,105.98 112.93,105.73 112.93,105.48 112.92,105.44 112.89,105.43 112.58,105.02 112.97,104.71 113,104.7 113.01,104.69 113.06,104.64 113.06,103.38 113.03,103.34 112.92,103.34 112.88,103.36 112.87,103.39 112.87,104.34 112.67,104.34 112.67,103.39 112.65,103.36 112.62,103.34 111.96,103.34 110.87,104.44 110.87,107.61 110.41,108.07 109.86,108.07 109.58,108.35 109.58,109.16 110.01,109.59 115.14,109.59 115.49,109.95 115.49,110.51 115.67,110.68 116.71,110.68 117.58,111.55 118.16,111.55 118.47,111.85 118.47,113.63 118.77,113.93 121.62,113.93
+VCC_CORE on TOP (solid shape): 70.56,70.75 70.64,70.71 70.66,70.62 70.79,70.19 71.24,70.19 71.29,70.23 71.32,70.27 71.4,70.31 71.48,70.27 71.62,70.16 71.79,70.13 71.83,70.12 72.02,69.93 72.03,69.91 72.04,69.89 72.04,68.01 71.92,67.9 70.89,67.9 70.72,68.07 70.72,68.52 70.64,68.59 70.64,69.13 70.44,69.33 70.29,69.33 70,69.62 70,70.6 70.16,70.75
+VCC_CORE on TOP (solid shape): outline of 999 points within 46.81,66.77 69.11,82.03
+VCC_CORE on BOTTOM (solid shape): 70.43,70.73 70.48,70.68 70.55,70.64 70.65,70.54 70.66,70.52 70.66,70.5 70.77,70.25 71.02,70.14 71.05,70.14 71.14,70.05 71.14,70.04 71.36,69.84 71.63,69.97 71.67,69.99 71.69,69.99 71.72,69.93 71.77,69.87 71.83,69.81 71.88,69.75 71.88,69.65 71.71,69.47 71.71,68.38 71.91,68.18 71.91,68.1 71.85,68.04 71.74,68.04 71.62,68.16 71.21,68.16 71.08,68.04 70.96,68.04 70.75,68.24 70.41,68.24 70.25,68.09 70.08,68.09 70.04,68.13 69.98,68.4 69.78,68.6 69.78,68.71 69.85,68.97 69.72,69.2 69.7,69.22 69.7,69.24 69.7,70.27 70.11,70.69 70.17,70.74 70.18,70.75 70.2,70.75 70.39,70.75
+VCC_CORE on BOTTOM (solid shape): 46.22,83.08 46.22,82.69 46.4,82.51 46.5,82.51 46.51,82.5 47.19,82.5 47.2,82.51 50.8,82.51 52.2,81.12 55.43,81.12 55.5,81.06 55.58,81.03 55.59,81.03 55.75,80.86 55.75,79.65 55.73,79.62 55.71,79.62 55.4,79.26 55.71,78.91 55.73,78.91 55.75,78.88 55.75,77.87 55.61,77.73 55.41,77.73 55.06,78.08 54.27,78.08 53.91,77.95 53.72,77.61 53.72,77.59 53.69,77.56 52.63,77.56 52.6,77.57 52.59,77.58 52.24,77.72 51.96,77.48 51.95,77.47 51.13,76.65 50.14,76.65 50.13,76.65 50.01,76.67 49.9,76.65 49.89,76.65 47.88,76.65 46.1,78.43 43.72,78.43 43.69,78.44 43.67,78.48 43.67,79.4 43.7,79.42 43.7,81.11 43.17,81.11 43.17,79.42 43.2,79.4 43.2,78.65 43.06,78.51 41.9,78.51 41.07,79.34 41.07,82.13 42.21,83.27 46.04,83.27
+VCC_CORE on BOTTOM (solid shape): 66.88,70.35 66.9,70.34 66.92,70.32 67.04,70.2 67.19,70.15 67.21,70.14 67.37,69.98 67.42,69.92 67.48,69.87 67.82,69.54 68.4,69.54 68.57,69.36 68.6,69.28 68.56,69.21 68.43,68.81 68.77,68.56 68.83,68.54 68.86,68.48 68.92,68.36 69.03,68.29 69.05,68.28 69.06,68.26 69.06,68.09 68.84,67.86 68.63,67.86 68.59,67.9 68.56,67.94 68.51,67.98 68.33,68.16 68.32,68.18 68.22,68.39 68.01,68.49 68,68.49 67.86,68.63 67.86,68.64 67.58,68.81 67.35,68.59 67.34,68.58 67.26,68.49 67.08,68.49 67.04,68.45 66.99,68.42 66.95,68.38 66.93,68.37 66.91,68.37 66.76,68.37 66.74,68.37 66.73,68.38 66.52,68.49 66.29,68.45 66.27,68.44 66.19,68.37 65.99,68.37 65.91,68.44 65.92,68.56 65.91,68.63 65.91,69.59 66.18,69.86 66.19,69.86 66.28,69.92 66.34,70.01 66.34,70.02 66.68,70.35
+VCC_CORE on VCC (solid shape): outline of 4710 points within 41.53,67.4 71.91,81.75
+VCC_CORE on IN1 (solid shape): outline of 2346 points within 48.54,66.89 72.14,81.63
+VDDQ_VTT on TOP (solid shape): 52.75,30.03 52.75,29.01 52.53,28.79 50.48,28.79 50.3,28.97 50.3,29.84 50.72,30.26 52.52,30.26
+VDDQ_VTT on BOTTOM (solid shape): 35.87,50 35.87,49.04 35.66,48.83 34.24,48.83 33.99,49.08 33.99,49.3 33.96,49.33 33.96,50.13 34.04,50.21 35.66,50.21
+VDDQ_VTT on BOTTOM (solid shape): 34.57,52.24 34.57,51.4 33.97,50.8 33.13,50.8 33.13,50.81 33.13,51.61 33.22,51.71 33.52,51.71 34.16,52.35 34.46,52.35
+VDDQ_VTT on IN2 (solid shape): 35.86,52.15 35.86,47.9 35.67,47.71 33.79,47.71 33.66,47.84 33.66,52.45 34.09,52.88 35.14,52.88
+VDDQ_VTT on IN2 (solid shape): 52.89,29.62 52.89,29.24 52.56,28.91 50.31,28.91 50.3,28.92 50.25,28.92 49.83,29.34 47.64,29.34 47.44,29.54 47.44,30.75 47.56,30.88 51.64,30.88
+VDDQ_VTT_M0_M1_R on TOP (solid shape): outline of 1186 points within 50.48,29.32 96.59,46.89
+VDDQ_VTT_M0_M1_R on BOTTOM (solid shape): outline of 864 points within 51.5,34.36 57.34,48.84
+VDDQ_VTT_M0_M1_R on BOTTOM (solid shape): outline of 892 points within 87.99,34.76 92.95,48.21
+VIN on TOP (solid shape): 86.86,23.22 86.86,22.22 87.2,21.88 87.2,21.07 86.86,20.73 86.86,20.11 86.26,19.51 83.73,19.51 83.44,19.79 83.44,22.98 83.47,23.01 83.47,23.2 83.58,23.31 85.6,23.31 85.76,23.47 86.61,23.47
+VIN on TOP (solid shape): 104.14,110.12 104.14,110.09 104.28,109.96 104.96,109.96 105.14,109.77 105.14,108.76 105.07,108.69 102.93,108.69 102.66,108.96 102.66,109.78 102.67,109.8 102.73,109.84 102.79,109.88 102.85,109.96 102.89,110.06 102.89,110.08 103.14,110.32 103.94,110.32
+VIN on TOP (solid shape): 25.72,56.77 25.72,53.44 25.51,53.24 25.48,53.22 25.43,53.2 25.39,53.17 25.35,53.13 25.32,53.09 25.29,53.04 25.28,53.01 23.65,51.37 19.94,51.37 19.51,51.81 19.51,54.29 21.05,54.29 21.05,54.23 21.06,54.18 21.08,54.13 21.1,54.08 21.13,54.03 21.17,53.99 21.21,53.96 21.26,53.93 21.31,53.91 21.36,53.9 21.41,53.9 21.47,53.9 21.52,53.91 21.57,53.93 21.62,53.96 21.66,53.99 21.7,54.03 21.73,54.08 21.75,54.13 21.77,54.18 21.78,54.23 21.78,54.29 21.77,54.34 21.75,54.39 21.73,54.44 21.7,54.49 21.66,54.53 21.62,54.56 21.57,54.59 21.52,54.61 21.47,54.62 21.41,54.62 21.36,54.62 21.31,54.61 21.26,54.59 21.21,54.56 21.17,54.53 21.13,54.49 21.1,54.44 21.08,54.39 21.06,54.34 21.05,54.29 19.51,54.29 19.51,55.01 21.57,57.06 25.43,57.06
+VIN on TOP (solid shape): outline of 395 points within 23.63,78.32 55.12,93.13
+VIN on BOTTOM (solid shape): 129.79,100.68 129.79,97.14 129.66,97.01 127.17,97.01 126.93,97.24 126.93,100.56 127.22,100.85 129.63,100.85
+VIN on BOTTOM (solid shape): 28.8,86.1 28.8,81.19 28.48,80.87 24.81,80.87 23.89,81.79 23.89,85.45 23.89,85.47 23.9,85.49 24.02,85.6 24.68,85.6 25.3,86.22 28.68,86.22
+VIN on BOTTOM (solid shape): 142.14,112.47 142.16,112.46 142.18,112.45 142.35,112.28 142.35,110.43 142.2,110.28 138.24,110.28 138.23,110.29 138.23,112.28 138.4,112.45 138.42,112.46 138.44,112.47
+VIN on BOTTOM (solid shape): 24.46,53.61 24.46,52.09 24.69,51.86 25.1,51.86 25.22,51.73 25.22,48.25 23.78,46.8 23.78,45.23 23.32,44.77 20.24,44.77 19.89,45.13 19.89,48.4 19.8,48.49 19.8,48.55 19.79,48.55 19.79,50.45 19.13,51.12 19.13,53.48 19.46,53.81 24.26,53.81
+VIN on BOTTOM (solid shape): 54.79,93.79 54.79,93.36 54.93,93.21 54.93,93.01 56.52,93.01 56.52,93.03 56.54,93.07 56.57,93.08 56.84,93.08 56.88,93.07 56.89,93.03 56.89,93.01 58.34,93.01 58.5,92.85 58.5,91.81 58.42,91.74 53.47,91.74 53.32,91.89 53.32,93.41 53.8,93.89 54.69,93.89
+VIN on BOTTOM (solid shape): 131.59,66.38 131.6,66.37 131.95,66.15 132.27,66.4 134.21,66.4 134.21,66.41 136.42,66.41 136.53,66.31 136.53,62.53 136.91,62.14 136.91,61.04 136.81,60.94 131.48,60.94 131.47,60.94 131.42,60.97 131.4,61.01 131.42,61.05 131.56,61.3 131.48,61.58 131.46,61.6 131.43,61.67 131.46,61.75 131.57,62 131.46,62.26 131.43,62.33 131.46,62.41 131.5,62.46 131.49,62.89 131.07,63 130.97,63.01 130.93,63.09 130.93,63.35 130.56,63.72 126.37,63.72 126.11,63.97 126.11,64.76 126.32,64.96 126.78,64.96 127.13,65.32 127.13,66.13 127.41,66.41 130.6,66.41 130.61,66.41 131.54,66.41
+VIN on BOTTOM (solid shape): outline of 203 points within 84.58,17.69 97.85,22.96
+VIN on VCC (solid shape): outline of 18155 points within 17.4,15.63 153.42,102.45
+VIN on IN1 (solid shape): outline of 526 points within 126.86,96.36 142.37,112.43
+VIN_VCORE on BOTTOM (solid shape): 28.7,80.23 28.7,78.32 28.2,77.82 28.2,74.64 28.45,74.39 33.78,74.39 34.85,73.32 38.96,73.32 39.23,73.05 39.23,72.14 39.12,72.02 38.48,72.02 38.36,71.9 38.36,71.11 37.92,70.68 37.29,70.68 36.91,70.3 33.78,70.3 33.63,70.15 33.61,70.15 33.33,69.87 33.33,69.59 33.25,69.51 32.94,69.51 32.84,69.61 32.84,70.08 32.85,70.1 32.87,70.12 33.03,70.42 32.87,70.73 32.85,70.74 32.84,70.77 32.84,71.77 32.63,71.98 32.63,72 32.54,72.13 32.41,72.21 32.4,72.22 32.26,72.35 27.31,72.35 27.29,72.37 25.77,72.37 24.51,73.62 24.51,80.23 24.89,80.61 28.32,80.61
DVDD on BOTTOM (solid shape): 31.2,30.61 31.2,30.23 31.24,30.19 31.24,29.91 31.24,29.89 31.11,29.73 31.09,29.55 31.08,29.53 31.07,29.51 30.99,29.43 29.41,29.43 29.19,29.66 27.53,29.66 26.8,28.92 26.8,28.74 26.69,28.63 26.69,27.64 26.66,27.61 26.41,27.61 26.39,27.63 26.39,30.66 26.43,30.7 31.12,30.7
GND on TOP (solid shape): 10.77,19.85 10.77,15.69 10.69,15.61 6.5,15.61 6.43,15.69 6.43,19.9 6.5,19.98 10.64,19.98
GND on TOP (solid shape): 27.46,27.09 27.46,24.88 27.41,24.83 25.17,24.83 25.12,24.88 25.12,27.09 25.2,27.17 27.38,27.17
GND on TOP (solid shape): 50.93,85.31 50.93,82.64 50.55,82.26 47.88,82.26 46.86,83.28 46.86,85.49 47.17,85.79 50.45,85.79
GND on TOP (solid shape): 57.25,100.14 57.25,98.65 56.56,97.96 55.27,97.96 55.04,98.18 55.04,99.89 55.39,100.24 57.15,100.24
GND on TOP (solid shape): 61.15,35.73 61.15,33.63 60.39,32.87 59.89,32.87 59.71,33.04 59.71,36.19 59.94,36.41 60.47,36.41
GND on TOP (solid shape): 72.24,98.29 72.24,97.22 71.88,96.87 70.79,96.87 70.49,97.17 70.49,98.29 70.59,98.39 72.14,98.39
GND on TOP (solid shape): 106.55,30.79 106.55,29.81 106.12,29.38 104.47,29.38 103.84,30.01 103.84,31.18 104.06,31.41 105.94,31.41
GND on TOP (solid shape): 115.04,102.73 115.04,100.5 114.86,100.32 112.47,100.32 112.37,100.42 112.37,102.76 112.68,103.06 114.71,103.06
GND on TOP (solid shape): 31.37,64.35 31.37,62.53 30.15,61.31 26.93,61.31 26.89,61.34 26.89,61.9 27.09,62.11 27.09,65.28 27.18,65.37 30.35,65.37
GND on TOP (solid shape): 33.29,57.98 33.29,57.39 32.66,56.76 32.66,55.33 32.06,54.73 29.49,54.73 29.19,55.03 29.19,58.25 29.39,58.45 32.82,58.45
GND on TOP (solid shape): 65.74,92.32 65.74,92.14 65.25,91.66 60.73,91.66 60.58,91.51 59.49,91.51 59.23,91.76 59.23,93.28 59.94,93.99 64.07,93.99
GND on TOP (solid shape): 90.78,26.97 90.78,26.23 90.65,26.1 90.02,26.1 89.71,25.8 89.05,25.8 88.93,25.92 88.93,26.97 89.08,27.12 90.63,27.12
GND on TOP (solid shape): 155.12,62.51 155.12,61.05 154.79,60.72 151.89,60.72 151.53,61.08 151.53,62.78 151.7,62.95 154.68,62.95
GND on TOP (solid shape): 155.21,59.09 155.21,57.74 155.12,57.65 153.59,57.65 153.45,57.8 153.45,59.5 153.63,59.69 154.62,59.69
GND on TOP (solid shape): 45.39,26.56 45.39,25.8 45.15,25.56 43.83,25.56 43.83,25.56 41.9,25.56 41.7,25.76 41.7,26.84 41.78,26.93 45.02,26.93
GND on TOP (solid shape): 11.46,26.08 11.46,24.76 11.38,24.68 10.39,24.68 10.29,24.78 10.29,25.28 10.26,25.31 10.26,25.49 10.29,25.51 10.29,26.15 10.36,26.23 11.3,26.23
GND on TOP (solid shape): 155.02,68.01 155.02,66.45 154.6,66.03 154.6,65.88 154.3,65.58 151.57,65.58 151.47,65.68 151.47,67.74 151.89,68.16 154.86,68.16
GND on TOP (solid shape): 36.37,27.98 36.37,26.46 36.68,26.15 36.68,20.72 36.53,20.56 35.55,20.56 35.48,20.64 35.48,28.02 35.74,28.29 36.07,28.29
GND on TOP (solid shape): 96.76,26.38 96.76,26.1 96.98,25.88 96.98,25.44 96.22,24.68 95.89,24.68 94.77,25.79 94.62,25.79 94.41,26.01 93.92,26.01 93.92,26.75 94.08,26.91 96.22,26.91
GND on TOP (solid shape): 15.43,13.59 15.76,13.59 16.33,13.02 16.33,12.16 16.21,12.03 15.72,12.03 15.35,11.66 14.85,11.66 14.78,11.73 14.78,13.55 14.43,13.91 14.43,14.11 14.56,14.24 14.78,14.24
GND on TOP (solid shape): 21.63,79.71 21.63,78.76 21.9,78.5 21.9,75.78 21.67,75.56 19.46,75.56 19.05,75.96 19.05,78.98 19.23,79.16 19.99,79.16 20.1,79.28 20.24,79.28 20.87,79.91 21.44,79.91
GND on TOP (solid shape): 41.88,65.83 41.94,65.83 41.97,65.81 41.99,65.78 41.99,64.35 41.83,64.2 39.57,64.2 39.37,64.4 39.37,66.13 39.5,66.26 41.45,66.26
GND on TOP (solid shape): 82.93,85.04 82.93,83.07 82.42,82.57 81.94,82.57 81.75,82.38 81.75,82.07 81.52,81.83 81.18,81.83 80.97,82.05 80.97,82.92 81.75,83.7 81.75,85.02 81.89,85.16 82.81,85.16
GND on TOP (solid shape): 117.74,92 117.74,91.16 117.41,90.84 117.41,89.8 117.05,89.44 115.56,89.44 114.89,90.11 114.89,91.03 115.19,91.34 116.64,91.34 116.89,91.58 116.89,91.8 117.15,92.07 117.67,92.07
GND on TOP (solid shape): 16.35,15.78 16.35,15.5 16.51,15.33 17.25,15.33 17.32,15.26 17.32,14.85 16.52,14.05 15.62,14.05 15.5,14.17 15.5,14.67 15.21,14.96 15.21,15.79 15.22,15.8 16.32,15.8
GND on TOP (solid shape): 109.22,25.94 109.22,24.62 109.01,24.41 109.01,23.25 109.14,23.12 109.14,22.24 108.97,22.08 108.24,22.08 108.12,22.2 108.12,24.93 108.53,25.33 108.53,25.33 108.53,25.91 108.66,26.04 109.12,26.04
GND on TOP (solid shape): 145.57,99.13 145.57,98.39 145.65,98.31 146.25,98.31 146.79,97.78 146.79,97.08 146.58,96.87 144.75,96.87 144.39,97.24 144.39,97.84 144.02,98.21 144.02,98.98 144.25,99.22 145.48,99.22
GND on TOP (solid shape): 80.42,94.78 80.42,94 81.9,92.51 81.9,90 81.66,89.75 79.38,89.75 79.25,89.88 79.25,93.59 79.05,93.79 79.02,93.79 79.01,93.8 78.81,93.8 78.64,93.97 78.64,94.81 78.79,94.95 80.24,94.95
GND on TOP (solid shape): 88.17,78.46 88.17,78.01 87.95,77.79 87.1,77.79 86.8,77.49 86.8,76.66 86.73,76.58 86.25,76.58 85.94,76.27 85.32,76.27 85.16,76.42 85.16,76.87 84.56,77.47 84.56,77.92 84.81,78.17 87.02,78.17 87.43,78.58 88.04,78.58
GND on TOP (solid shape): 96.32,62.06 98.63,62.06 100.6,60.09 100.63,59.93 100.67,59.76 100.67,57.76 100.48,57.57 96.83,57.57 96.29,58.11 95.79,58.11 95.74,58.11 94.97,58.11 94.77,58.32 94.77,61.83 95.3,62.37 96.01,62.37
GND on TOP (solid shape): 39.38,53.19 39.38,52.35 39.27,52.24 38.3,52.24 37.87,51.81 37.87,49.16 38.1,48.94 39.47,48.94 39.63,49.09 39.96,49.09 40.11,48.94 40.11,47.72 39.5,47.11 37.06,47.11 36.65,47.51 36.65,52.62 37.34,53.3 39.27,53.3
GND on TOP (solid shape): 147.24,49.44 147.24,44.16 146.76,43.68 145.89,43.68 145.89,43.63 145.88,43.59 145.84,43.58 145.58,43.58 145.55,43.59 145.53,43.63 145.53,43.68 145.39,43.68 145.38,43.69 145.38,44.85 144.88,45.35 144.88,48.3 145.49,48.91 145.49,49.7 145.57,49.78 146.9,49.78
GND on TOP (solid shape): 11.77,11.31 11.77,11.03 11.72,10.98 10.94,10.98 10.7,10.74 10.7,9.97 10.7,9.97 10.68,9.65 10.7,9.33 10.7,9.33 10.7,8.55 10.95,8.31 10.95,7.94 10.79,7.79 10.49,7.79 9.93,8.35 9.93,9.97 9.49,10.41 9.12,10.41 8.37,11.16 8.37,11.28 8.48,11.39 11.69,11.39
GND on TOP (solid shape): 38.27,78.82 38.27,78.27 37.29,77.29 36.93,77.29 36.17,76.53 34.76,76.53 34.68,76.44 34.55,76.44 33.71,75.61 33.71,74.84 33.38,74.51 29.92,74.51 29.16,75.28 29.16,77.51 30.28,78.62 30.29,78.63 30.48,78.73 30.58,78.92 30.59,78.93 30.79,79.14 37.96,79.14
GND on TOP (solid shape): 98.7,25.12 98.7,24.28 98.74,24.27 98.76,24.23 98.76,24.07 98.83,23.99 100.03,23.99 100.05,23.97 100.05,22.09 99.95,21.99 98.12,21.99 98.05,22.06 98.05,23.89 98.38,24.22 98.38,24.25 98.4,24.28 98.42,24.28 98.42,25.11 98.44,25.15 98.47,25.16 98.65,25.16
GND on TOP (solid shape): 102.95,76.88 102.95,76.3 102.54,75.9 102.39,75.9 102.28,75.86 102.2,75.78 102.2,75.77 101.72,75.29 101.28,75.29 100.69,74.69 97.73,74.69 97.66,74.72 97.63,74.79 97.61,74.87 97.57,74.96 97.57,75.16 99.93,77.51 102.31,77.51
GND on TOP (solid shape): 15.98,83.29 16.28,83.29 16.33,83.3 16.45,83.3 16.95,82.8 16.95,81.83 16.82,81.7 16.74,81.66 16.68,81.59 16.66,81.58 16.64,81.57 15.95,81.57 15.33,82.19 14.7,82.19 14.51,82.38 14.51,82.97 14.83,83.29 15.01,83.29 15.06,83.3 15.93,83.3
GND on TOP (solid shape): 116.71,44.41 116.71,43.1 115.75,42.14 114.57,42.14 113.6,41.17 113.42,41.17 113.39,41.18 113.37,41.22 113.37,41.33 112.73,41.97 112.72,41.97 112.72,43.52 113.43,44.23 113.97,44.23 114.55,43.64 115.14,43.64 115.27,43.77 115.27,43.95 115.28,43.99 115.28,44.03 115.28,44.21 115.85,44.78 115.91,44.8 116.33,44.8
GND on TOP (solid shape): 15.19,21.55 15.22,21.54 15.24,21.5 15.24,21.06 15.18,21 15.17,20.99 14.9,20.63 15.2,20.3 15.21,20.29 15.24,20.27 15.24,20.12 15.05,19.93 13.05,19.93 13.02,19.96 13.02,20.37 13.14,20.49 14.02,20.49 14.59,21.06 14.59,21.49 14.65,21.55
GND on TOP (solid shape): 122.44,35.27 122.45,35.24 122.83,34.87 123.17,35.27 123.19,35.35 123.27,35.39 123.8,35.39 123.92,35.27 123.92,32.89 123.76,32.74 122.43,32.74 122.14,33.03 122.14,35.27 122.27,35.39 122.32,35.39
GND on TOP (solid shape): 14.31,53.05 14.31,51.28 14.02,50.99 6.04,50.99 5.56,50.5 4.51,50.5 3.27,49.26 2.95,49.26 2.66,49.56 2.66,51.89 8.69,51.89 9.58,51.89 10.71,51.43 11.46,52.4 11.46,53.59 11.58,53.71 13.64,53.71
GND on TOP (solid shape): 138.89,101.36 138.89,99 137.19,97.29 136.81,97.29 136.53,97.41 136.26,97.31 136.24,97.29 136.22,97.29 135.67,96.75 134.82,96.75 134.75,96.82 134.21,96.82 134.1,96.93 134.1,99.7 134.9,100.51 135.87,100.51 135.9,100.5 135.92,100.47 136.27,100.19 136.63,100.47 136.64,100.5 136.68,100.51 136.84,100.51 137.95,101.62 138.63,101.62
GND on TOP (solid shape): 153.78,110.09 154.05,109.94 154.35,109.83 154.53,109.64 154.53,107.86 154.23,107.56 154.23,106.59 153.98,106.34 153.49,106.34 153.28,106.13 153.06,106.13 152.89,105.96 148.97,105.96 148.85,106.09 148.85,106.37 148.97,106.49 153.01,106.49 153.01,108.19 153.15,108.33 153.17,108.35 153.2,108.35 153.58,108.54 153.52,108.96 153.52,109.26 153.62,109.51 153.52,109.77 153.52,109.92 153.7,110.1 153.77,110.1
GND on TOP (solid shape): 138.85,88.31 138.94,88.25 138.93,88.14 138.96,87.64 139.46,87.64 139.53,87.67 139.6,87.64 139.86,87.51 140.12,87.61 140.51,87.21 140.51,83.61 141.02,83.1 141.02,80.96 138.74,78.68 135.26,78.68 132.92,81.02 132.92,84.52 136.37,87.98 136.37,89.04 136.5,89.17 137.99,89.17
GND on TOP (solid shape): 114,77.49 114,76.67 114.86,75.81 115.37,75.81 115.49,75.68 115.49,75.56 115.21,75.27 115.21,75.24 115.14,75.17 115.14,74.79 115.24,74.7 115.24,74.68 115.32,74.58 115.44,74.54 115.72,74.54 115.87,74.6 115.93,74.74 115.93,74.77 116.03,74.87 116.03,74.97 116.28,75.22 116.47,75.22 116.75,74.94 116.77,74.94 116.82,74.89 117.17,74.89 117.45,74.62 117.45,73.12 117.3,72.96 114.91,72.96 113.49,74.39 113.48,74.4 113.39,74.57 113.22,74.66 113.21,74.67 112.93,74.95 112.93,77 112.94,77.04 112.97,77.05 113.21,77.22 113.25,77.51 113.26,77.6 113.35,77.64 113.84,77.64
GND on TOP (solid shape): 130.85,60.6 130.86,60.56 130.88,60.51 130.91,60.47 130.95,60.43 130.99,60.39 131.04,60.36 131.08,60.34 131.12,60.33 131.43,60.02 131.43,59.77 131.64,59.56 134.71,59.56 135.88,58.4 136.98,58.4 137.01,58.39 137.03,58.37 137.03,58.35 137.03,57.78 136.85,57.59 136.59,57.59 136.56,57.59 136.51,57.58 136.48,57.56 131.78,57.56 131.66,57.45 127.64,57.45 127.53,57.55 127.53,58.16 134.82,58.16 134.82,58.1 134.83,58.05 134.84,58 134.87,57.95 134.9,57.9 134.93,57.86 134.98,57.83 135.02,57.8 135.07,57.78 135.13,57.77 135.18,57.77 135.23,57.77 135.29,57.78 135.34,57.8 135.39,57.83 135.43,57.86 135.46,57.9 135.49,57.95 135.52,58 135.53,58.05 135.54,58.1 135.54,58.16 135.53,58.21 135.52,58.26 135.49,58.31 135.46,58.36 135.43,58.4 135.39,58.43 135.34,58.46 135.29,58.48 135.23,58.49 135.18,58.49 135.13,58.49 135.07,58.48 135.02,58.46 134.98,58.43 134.93,58.4 134.9,58.36 134.87,58.31 134.84,58.26 134.83,58.21 134.82,58.16 127.53,58.16 127.53,58.21 127.38,58.36 127.38,60.34 128.22,61.17 129.37,61.17 129.49,61.28 130.17,61.28
GND on TOP (solid shape): 20.32,71.47 20.32,66.08 18.56,64.33 11.81,64.33 11.46,64.68 11.46,66.1 10.71,67.07 9.58,66.61 8.48,66.61 2.66,66.61 2.66,68.75 2.36,69.46 1.65,69.76 1.41,69.76 1.41,70.74 2.66,70.74 7.52,70.74 8.21,71.24 8.01,72.06 8.01,72.92 8.33,73.24 18.54,73.24
GND on TOP (solid shape): 117.16,80.89 117.16,79.47 118.01,78.62 118.01,78.4 117.53,77.92 117.53,76.77 118.07,76.22 118.33,76.22 118.4,76.15 118.41,76.13 118.4,76.11 118.66,75.67 119.11,75.93 119.11,75.94 119.41,76.24 120.7,76.24 121.03,75.91 121.05,75.88 121.03,75.84 120.92,75.73 120.92,73.57 120.78,73.42 119.53,73.42 119.43,73.52 119.43,73.93 119.05,74.31 119.03,74.31 118.99,74.34 118.64,74.34 118.42,74.56 118.42,75.17 117.75,75.84 117.75,75.84 117.31,76.28 117.31,76.29 117.22,76.42 117.09,76.51 117.08,76.51 116.97,76.62 116.97,77.03 116.84,77.16 116.77,77.16 116.72,77.18 116.67,77.18 116.56,77.18 116.46,77.28 116.46,77.41 116.82,77.77 116.82,77.95 116.87,77.99 116.87,78.65 116.69,78.83 115.11,78.83 115.01,78.93 115.01,79.64 115.32,79.95 115.88,79.95 115.92,79.99 115.94,80 116.21,80.17 116.24,80.5 116.23,80.51 116.23,81.14 116.33,81.24 116.82,81.24
GND on TOP (solid shape): 158.17,91.26 158.17,90.82 157.85,90.51 151.97,90.51 150.93,90.07 150.49,89.03 150.49,79.97 150.93,78.93 151.97,78.49 156.31,78.49 156.6,78.49 156.95,78.35 157.09,78 157.09,74.84 156.84,74.59 154.72,74.59 151.83,77.48 150.16,78.28 149.48,80 149.48,80.5 149.48,89.07 149.48,89.07 150.24,90.81 152,91.52 153.04,91.52 157.9,91.52
GND on TOP (solid shape): 6.73,8.85 6.9,8.41 7,7.94 6.78,6.35 5.78,5.1 4.1,5.1 4.1,0.9 5.3,0.9 5.3,0.9 5.72,0.9 7.17,2.35 7.22,2.42 7.24,2.51 7.24,3.55 7.91,4.21 7.92,4.22 8.02,4.29 8.06,4.41 8.06,6.04 8.15,6.17 8.25,6.3 9.35,6.3 9.44,6.24 9.42,6.13 8.02,3.95 7.35,1.45 7.33,1.45 7.3,0.97 7.15,0.64 6.81,0.51 3.8,0.51 3.45,0.65 3.31,1 3.31,5.54 4,5.54 5.55,6.28 5.97,7.94 5.85,8.34 5.65,8.7 5.71,8.77 5.76,8.85
GND on TOP (solid shape): outline of 145 points within 70.79,70.98 73.67,74.69
GND on TOP (solid shape): outline of 174 points within 87.19,73.13 95.96,77.07
GND on TOP (solid shape): outline of 250 points within 71.53,66.31 81.1,70.6
GND on TOP (solid shape): outline of 580 points within 16.41,9.41 157.09,54.49
GND on TOP (solid shape): outline of 698 points within 1.41,85.56 152.57,115.49
GND on BOTTOM (solid shape): 10.8,19.85 10.8,15.74 10.67,15.61 6.5,15.61 6.38,15.74 6.38,19.8 6.58,20.01 10.64,20.01
GND on BOTTOM (solid shape): 27.46,27.12 27.46,24.88 27.41,24.83 25.15,24.83 25.1,24.88 25.1,27.12 25.17,27.19 27.38,27.19
GND on BOTTOM (solid shape): 29.2,31.64 29.2,30.93 29.12,30.86 26.51,30.86 26.39,30.98 26.39,32.25 26.45,32.32 28.52,32.32
GND on BOTTOM (solid shape): 30.3,65.22 30.3,62.02 30.18,61.89 27.03,61.89 26.87,62.04 26.87,65.12 27.08,65.32 30.2,65.32
GND on BOTTOM (solid shape): 41.99,66.77 41.99,64.3 41.89,64.2 39.6,64.2 39.4,64.4 39.4,66.72 39.5,66.82 41.94,66.82
GND on BOTTOM (solid shape): 85.75,103.24 85.75,99.99 85.55,99.79 83.87,99.79 83.01,100.65 83.01,102.91 83.52,103.42 85.57,103.42
GND on BOTTOM (solid shape): 107.53,31.28 107.53,28.47 106.02,26.97 103.71,26.97 103.68,26.99 103.68,30.65 104.45,31.41 107.39,31.41
GND on BOTTOM (solid shape): 115.04,102.94 115.04,100.57 114.94,100.47 112.6,100.47 112.52,100.55 112.52,102.91 112.68,103.06 114.91,103.06
GND on BOTTOM (solid shape): 138.65,92.99 138.65,90.76 138.44,90.55 137.73,90.55 137.36,90.93 137.36,92.9 137.56,93.11 138.53,93.11
GND on BOTTOM (solid shape): 140.95,68.23 140.95,66.84 140.33,66.22 137.54,66.22 137.4,66.36 137.4,68.02 138.32,68.94 140.23,68.94
GND on BOTTOM (solid shape): 21.97,79.38 21.97,75.15 21.74,74.92 19.31,74.92 19,75.23 19,76.5 19.41,76.91 19.41,79.12 20.14,79.84 21.51,79.84
GND on BOTTOM (solid shape): 34.9,44.69 34.9,39.77 34.55,39.41 33.05,39.41 32.92,39.54 32.92,44.95 33.02,45.05 34.55,45.05
GND on BOTTOM (solid shape): 37.8,52.52 37.8,47.95 37.59,47.74 35.76,47.74 35.61,47.89 35.61,48.5 36.09,48.98 36.09,51.37 37.36,52.64 37.67,52.64
GND on BOTTOM (solid shape): 120.19,79.34 120.19,79.22 120.11,79.14 119.12,79.14 118.72,79.53 118.72,79.95 118.89,80.12 119.11,80.12 119.12,80.13 119.4,80.13
GND on BOTTOM (solid shape): 128.11,113.81 128.11,112.93 126.48,111.31 124.33,111.31 124.16,111.48 124.16,113.7 124.42,113.95 127.97,113.95
GND on BOTTOM (solid shape): 141.95,69.76 141.95,69.03 141.69,68.77 140.73,68.77 140.36,69.14 139.26,69.14 139.05,69.36 139.05,69.93 139.22,70.11 141.59,70.11
GND on BOTTOM (solid shape): 66.35,30.09 66.35,29.38 66.29,29.31 65.7,29.31 65.44,29.05 59.44,29.05 59.23,29.25 59.23,30.17 59.46,30.39 66.05,30.39
GND on BOTTOM (solid shape): 32.72,50.76 32.72,49.49 32.59,49.37 31.34,49.37 31.24,49.47 31.24,50.79 31.26,50.83 31.29,50.84 32.64,50.84
GND on BOTTOM (solid shape): 109.83,38.78 109.83,37.15 109.82,37.14 109.82,36.01 109.72,35.9 108.93,35.9 108.76,35.73 108.33,35.73 108.28,35.78 108.28,38.88 108.46,39.06 109.55,39.06
GND on BOTTOM (solid shape): 138.46,29.63 138.46,27.6 137.77,26.91 135.67,26.91 135.64,26.93 135.62,26.97 135.62,29.9 135.71,29.99 138.1,29.99
GND on BOTTOM (solid shape): 154.08,99.41 154.08,98.2 152.87,96.99 151.99,96.99 151.96,97.01 151.94,97.04 151.94,99.48 152.35,99.89 153.6,99.89
GND on BOTTOM (solid shape): 29.67,96.41 29.67,94.07 29.29,93.69 25.4,93.69 25.3,93.79 25.3,94.48 25.66,94.83 25.66,96.05 26.34,96.74 29.34,96.74
GND on BOTTOM (solid shape): 75.74,26.76 77.6,26.76 77.93,26.43 77.93,24.45 80.65,21.73 80.65,20.01 80.29,19.65 75.74,19.65 74.96,20.43 74.96,26.84 75.06,26.94 75.57,26.94
GND on BOTTOM (solid shape): 78.64,30.22 78.64,29.3 78.51,29.17 75.74,29.17 74.85,28.28 72.28,28.28 71.84,28.73 71.84,29.44 71.84,29.44 71.84,29.49 72.87,30.52 78.33,30.52
GND on BOTTOM (solid shape): 152.55,106.96 152.55,105.8 152.48,105.74 149.15,105.74 148.88,106.01 148.88,106.69 148.89,106.72 148.93,106.74 149.78,106.74 150.13,107.09 152.41,107.09
GND on BOTTOM (solid shape): 27.97,52.88 27.97,48.4 26.95,47.39 26.95,46.57 26.87,46.5 24.51,46.5 24.33,46.68 24.33,47.13 25.35,48.15 25.35,51.83 25.2,51.98 24.77,51.98 24.61,52.14 24.61,53.35 24.79,53.53 27.32,53.53
GND on BOTTOM (solid shape): 34.42,34.28 34.42,32.6 33.91,32.09 31.54,32.09 31.23,32.4 28.94,32.4 28.63,32.71 27.53,32.71 27.41,32.83 27.41,33.44 27.59,33.62 28.5,33.62 28.63,33.75 28.63,34.43 28.78,34.59 34.11,34.59
GND on BOTTOM (solid shape): 22.81,63.52 22.81,62.7 23.29,62.22 23.47,62.22 23.78,61.92 23.78,61.46 22.86,60.54 22.07,60.54 21.85,60.32 21.85,59.1 21.64,58.89 21.29,58.89 21.16,59.02 21.16,61.31 19.79,62.68 19.79,63.54 20.22,63.97 22.35,63.97
GND on BOTTOM (solid shape): 147.12,49.19 147.12,47.14 146.84,46.85 146.64,46.85 146.63,46.86 146.35,46.93 146.08,46.85 145.65,46.85 145.5,47.01 145.5,49.13 145.66,49.29 147.02,49.29
GND on BOTTOM (solid shape): 100.13,24.27 100.13,21.61 99.82,21.3 98.27,21.3 98.05,21.53 98.05,24.35 98.19,24.49 98.23,24.5 98.63,24.4 99,24.58 99.82,24.58
GND on BOTTOM (solid shape): 143.23,54.4 144.77,54.4 144.78,54.4 144.78,54.1 143.23,54.1 143.23,53.9 144.78,53.9 144.78,53.6 143.23,53.6 143.23,53.4 144.78,53.4 144.78,53.1 143.23,53.1 143.23,52.9 144.78,52.9 144.78,52.62 144.77,52.61 141.26,52.61 141.07,52.8 141.07,54.3 141.2,54.42 143.23,54.42
GND on BOTTOM (solid shape): 116.58,44.73 116.58,43.76 116.59,43.75 116.59,43.71 116.51,43.63 115.37,43.63 115.32,43.58 115.32,41.72 115.29,41.7 114.81,41.7 114.8,41.71 114.8,43.45 114.78,43.47 114.08,43.47 114.06,43.45 114.06,41.71 114.04,41.7 113.53,41.7 113.53,41.7 113.53,43.44 113.16,43.81 113.16,44.44 113.62,44.9 116.41,44.9
GND on BOTTOM (solid shape): 122.77,92.16 123.16,92.16 123.53,91.79 123.53,85.63 123.49,85.59 121.83,85.59 121.45,85.97 121.45,88.45 121.48,88.75 121.28,88.97 121.27,88.98 120.98,89.26 120.96,89.26 120.96,91.91 121.21,92.17 122.76,92.17
GND on BOTTOM (solid shape): 61.14,93.56 61.14,92.8 61.24,92.7 61.42,92.7 61.42,92.69 62.12,92.69 62.13,92.7 62.15,92.7 62.66,93.21 63.63,93.21 63.7,93.13 63.7,92.6 63.45,92.34 62.82,92.34 62.15,91.68 59.06,91.68 59.01,91.74 59.01,92.78 59.16,92.93 60.43,92.93 60.53,93.03 60.53,93.41 60.56,93.44 60.56,93.65 60.62,93.71 60.99,93.71
GND on BOTTOM (solid shape): 38.29,78.76 38.29,78.45 38.13,78.28 38.13,76.19 37.91,75.97 34.98,75.97 34.98,75.96 34.97,75.93 34.93,75.91 34.8,75.91 34.55,75.66 34.55,74.77 34.29,74.51 28.58,74.51 28.45,74.64 28.45,77.43 29.71,78.69 30.01,78.69 30.23,78.62 30.44,78.69 36.62,78.69 36.96,79.04 38.02,79.04
GND on BOTTOM (solid shape): 141.06,77.39 141.18,77.39 141.21,77.38 141.23,77.34 141.23,76.22 141.04,76.03 139.03,76.03 138.81,75.81 138.79,75.81 138.65,75.72 138.56,75.57 138.56,75.56 138.31,75.32 136.57,75.32 136.51,75.37 136.51,75.7 136.53,75.72 137.82,75.72 137.96,75.86 137.96,76.67 137.96,76.69 137.97,76.71 138.51,77.25 139.43,77.25 139.93,77.74 139.95,77.75 139.97,77.76 140.7,77.76
GND on BOTTOM (solid shape): 146.13,99.42 146.16,99.41 146.18,99.37 146.18,99.36 146.63,98.91 146.66,98.82 146.38,98.43 146.51,98.06 146.75,97.81 146.75,97.31 146.65,97.2 143.8,97.2 143.4,97.61 143.4,99.36 143.46,99.42
GND on BOTTOM (solid shape): 17.48,28.01 17.48,26.74 17.05,26.31 17.03,26.31 16.91,26.27 16.8,26.2 16.72,26.16 16.64,26.21 16.38,26.37 16.09,26.28 16.02,26.25 15.95,26.28 15.6,26.63 15.6,28.01 15.7,28.11 17.37,28.11
GND on BOTTOM (solid shape): 116.69,95.06 116.69,94.86 116.61,94.63 116.69,94.4 116.69,93.79 116.49,93.59 111.28,93.59 111.23,93.54 111.23,91.43 111.05,91.25 103.96,91.25 103.95,91.26 103.78,91.3 103.62,91.26 103.61,91.25 101.75,91.25 101.63,91.38 101.63,92.17 101.7,92.24 105.56,92.24 105.73,92.42 105.73,94.31 106.34,94.92 110.63,94.92 110.97,95.27 116.49,95.27
GND on BOTTOM (solid shape): 47.96,75.81 47.96,72.53 47.95,72.52 47.95,72.15 47.85,72.05 47.3,72.05 47.26,72.09 47.26,72.19 47.21,72.67 46.73,72.68 46.7,72.67 46.66,72.68 45.8,73.55 45.8,74.11 45.98,74.29 46.97,74.29 47.09,74.41 47.09,75.86 47.17,75.94 47.83,75.94
GND on BOTTOM (solid shape): 97.71,24.96 97.71,24.83 97.77,24.77 97.77,23.53 97.59,23.35 96.54,23.35 96.05,22.87 96.05,22.61 95.98,22.54 95.13,22.54 95.1,22.59 95.07,22.64 95.07,23.49 95.53,23.95 95.53,24.76 95.44,24.85 95.43,24.85 95.19,25.05 94.87,25.02 94.86,25.01 94.84,25.01 94.59,24.76 93.73,24.76 93.7,24.78 93.7,26.41 94.21,26.91 95.76,26.91
GND on BOTTOM (solid shape): 142.85,37.46 142.85,37.28 142.93,37.2 143.89,37.2 144.3,36.79 144.3,35.7 143.69,35.09 140.79,35.09 140.76,35.11 140.74,35.14 140.74,35.89 140.78,35.98 140.87,35.99 141.29,36.15 141.24,36.59 140.85,36.98 140.85,37.26 141.2,37.61 142.7,37.61
GND on BOTTOM (solid shape): 146.3,71.52 146.3,69.59 147.03,68.86 148.14,68.86 148.21,68.9 148.3,68.88 148.45,68.72 148.45,68.27 148.32,68.13 145.36,68.13 144.95,68.54 144.95,69.97 144.82,70.1 143.23,70.1 143.22,70.11 143.22,70.39 143.23,70.4 144.77,70.4 144.78,70.41 144.78,70.59 144.78,70.6 143.23,70.6 143.23,70.6 143.23,70.9 143.23,70.9 144.77,70.9 144.78,70.91 144.78,71.09 144.78,71.1 143.23,71.1 143.21,71.11 143.21,71.36 143.23,71.39 143.26,71.41 144.8,71.41 144.98,71.59 146.23,71.59
GND on BOTTOM (solid shape): 46.34,27.55 46.34,26.76 46.51,26.59 47.6,26.59 47.73,26.71 47.73,27.22 47.85,27.34 49.01,27.34 49.18,27.17 49.18,26.72 49.07,26.61 48.61,26.61 47.81,25.8 47.81,25.59 48.01,25.22 48.43,25.29 49.02,25.88 49.33,25.88 49.57,25.65 49.57,24.66 49.54,24.63 49.53,24.62 49.51,24.62 47.63,24.62 47.08,25.16 45.91,25.16 45.6,24.86 44.93,24.86 44.22,25.57 44.22,26.82 45.11,27.71 46.18,27.71
GND on BOTTOM (solid shape): 95.3,89.32 95.3,88.57 94.44,87.71 94.44,87.11 94.41,87.05 94.4,86.98 94.4,86.83 94.39,86.79 94.35,86.78 93.59,86.78 93.56,86.79 93.54,86.83 93.54,87.18 93.57,87.21 93.59,87.21 93.89,87.68 93.37,87.89 93.27,87.89 93.22,87.98 93.22,89.63 93.35,89.75 94.87,89.75
GND on BOTTOM (solid shape): 13.89,52.73 15.2,52.73 15.35,52.58 15.35,52.26 15.1,52.02 15.1,51.55 15.44,51.22 15.44,50.79 15.33,50.68 15.28,50.73 15.11,50.73 14.83,51.01 11.92,51.01 11.85,50.94 11.77,50.87 9.12,50.87 9.11,50.88 5.64,50.88 3.67,50.88 3.67,49.62 3.32,49.27 2.81,49.27 2.66,49.42 2.66,51.89 8.59,51.89 9.58,51.89 10.71,51.43 11.46,52.4 11.46,53.56 11.61,53.71 12.9,53.71
