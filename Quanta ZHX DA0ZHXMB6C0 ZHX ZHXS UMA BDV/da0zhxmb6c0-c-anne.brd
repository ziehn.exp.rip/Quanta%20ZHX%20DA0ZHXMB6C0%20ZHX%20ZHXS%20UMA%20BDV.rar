# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A14: length 69
  TOP w0.089: U25.T7 65.55,39.49 65.31,39.25 65.31,39.07 64.73,38.49 64.09,38.49 63.95,38.35 v3(63.66,38.06) ; v3(45.87,38.05) 46.16,38.33 46.16,38.33 46.25,38.42 46.77,38.42 46.86,38.51 46.86,38.52 47.76,39.43 47.76,40.17 U24.T7 ; 60.48,59 60.54,59.06 60.54,59.49 60.85,59.79 60.85,59.86 61.26,60.27 v1(61.26,60.9)
  TOP w0.117: R1067.2 52.8,37.76 53.46,37.76 53.52,37.83 v1(54.06,37.83) 53.68,38.22 53.4,38.22 53.1,38.52 53.1,38.97 53.31,39.18 53.31,39.52 53.2,39.64 53,39.64 52.88,39.75 52.88,39.99 53,40.1 53.2,40.1 53.31,40.22 53.31,40.9 53.27,40.93 53.27,41.51 52.84,41.95 52.84,41.95 52.73,42.06 52.73,44.08 52.05,44.76 52.05,51.99 50.86,53.18 50.86,54.98 52.45,56.56 54.69,56.56 55.25,57.13 55.35,57.13 56.43,58.21 57.06,58.21 57.19,58.08 58.08,58.08 59.25,59.25 59.85,59.25 60.16,58.94 60.41,58.94 60.48,59
  IN2 w0.102: v3(63.66,38.06) 63.65,38.05 62.89,38.05 62.65,37.81 55.79,37.81 55.69,37.71 55.05,37.71 54.9,37.86 54.1,37.86 v1(54.06,37.83) 53.69,37.45 48.78,37.45 47.82,38.42 47.57,38.42 47.47,38.31 47.47,38.01 47.34,37.88 47.19,37.88 47.06,38.01 47.06,38.31 46.96,38.42 45.98,38.42 45.87,38.31 v3(45.87,38.05)
  BOTTOM w0.089: U32.T7 62.35,39.62 62.66,39.31 62.66,39.16 62.52,39.03 62.52,38.85 62.6,38.77 62.77,38.77 62.91,38.91 63.08,38.91 63.24,38.74 63.24,38.71 63.38,38.57 63.38,38.35 63.45,38.27 v3(63.66,38.06) ; U7.BD47 v1(61.26,60.9) ; U31.T7 44.57,39.52 44.41,39.36 44.41,39.16 44.57,39.01 44.57,38.86 44.78,38.64 45.49,38.64 45.87,38.26 v3(45.87,38.05)
M_A_A15: length 68.9
  TOP w0.089: v3(47.23,43.5) 47.23,43.51 47.23,43.51 47.23,43.87 47.09,44.01 46.85,44.01 46.76,43.92 46.76,43.28 47.08,42.97 47.3,42.97 47.46,43.12 47.52,43.12 U24.M7 ; U25.M7 65.71,43.21 65.71,43 65.62,42.91 65.24,42.91 65.09,43.06 64.7,43.06 64.64,43 64.52,43 64.43,43.09 64.43,43.21 64.25,43.39 v3(64.25,43.71)
  IN1 w0.102: v1(60.28,60.88) 60.28,60.38 59.89,59.99 59.52,59.99 59.25,60.26 59.25,61.05 59.14,61.15 58.92,61.15 58.83,61.06 58.83,60.34 58.73,60.23 58.56,60.23 58.18,60.62 57.82,60.62 57.55,60.35 57.55,60.02 57.83,59.74 58.28,59.74 58.46,59.56 58.46,58.59 58.28,58.41 58.28,58.34 58.06,58.12
  IN1 w0.135: v1(52.22,43.97) 51.54,44.64 51.27,44.64 51.04,44.41 51.04,44.07 50.86,43.89 50.55,43.89 50.29,44.15 50.29,45.04 50.8,45.55 50.8,46.44 50.9,46.54 50.9,47.01 51.49,47.59 51.49,48.31 51.49,48.31 51.49,50.5 51.49,50.5 51.49,50.79 51.88,51.18 51.88,53.68 52.49,54.29 52.49,54.73 52.86,55.1 53.24,55.1 53.55,55.41 53.55,55.79 53.82,56.06 54.75,56.06 55.4,56.71 55.4,57.26 55.93,57.79 56.18,57.79 56.37,57.6 56.37,57.4 56.55,57.22 56.9,57.22 57.26,57.58 57.26,57.94 57.44,58.12 58.06,58.12
  IN2 w0.102: v3(64.25,43.71) 64.23,43.71 64.18,43.76 63.48,43.76 63.21,43.49 63.19,43.49 63.14,43.45 61.67,43.45 61.57,43.55 60.01,43.55 59.78,43.32 57.37,43.32 56.97,43.73 56.67,43.73 56.24,44.16 54.17,44.16 53.97,43.97 v1(52.22,43.97) 52.61,44.36 53.91,44.36 54.06,44.51 54.06,44.65 53.96,44.74 52.17,44.74 51.46,44.03 51.29,44.03 51.2,43.95 51.2,43.82 51.3,43.72 51.62,43.72 51.72,43.62 51.72,43.47 51.62,43.37 51.19,43.37 51.03,43.53 50.64,43.53 50.52,43.4 50.36,43.4 50.18,43.57 48.67,43.57 48.3,43.19 48.15,43.19 48,43.34 47.86,43.34 47.71,43.19 47.26,43.19 47.18,43.27 47.18,43.43 47.23,43.48 v3(47.23,43.5)
  BOTTOM w0.089: U32.M7 62.35,43.52 62.35,43.53 62.35,43.73 62.43,43.82 62.58,43.82 62.68,43.72 62.9,43.5 62.9,43.5 62.97,43.44 63.31,43.44 63.65,43.78 63.88,43.78 63.94,43.71 v3(64.25,43.71) ; v3(47.23,43.5) 47.23,43.54 47.08,43.69 46.1,43.69 46.04,43.63 45.66,43.63 45.63,43.66 44.86,43.66 U31.M7 ; U7.BD49 v1(60.28,60.88)
  BOTTOM w0.117: v1(52.22,43.97) 52.22,44.69 52.73,45.21 R1070.2
M_A_BS0: length 72
  TOP w0.089: v3(46.53,42.99) 46.44,42.9 46.29,42.9 46.06,42.67 45.73,42.67 45.51,42.9 45.15,42.9 44.99,43.05 44.32,43.05 44.15,42.88 43.88,42.88 43.77,42.99 U24.M2 ; v3(64.94,42.69) 64.82,42.8 64.37,42.8 64.23,42.95 63.28,42.95 63.24,42.99 61.92,42.99 U25.M2
  TOP w0.117: R1062.2 56.21,42.74 v1(55.81,43.14) 55.59,43.37 55.52,43.37 55.01,43.87 54.81,43.87 54.69,44 54.69,45.28 54.54,45.42 54.23,45.42 54.05,45.6 54.05,45.87 54.19,46.01 54.19,46.24 54.03,46.41 54.03,49.22 54.03,49.22 54.03,49.68 54.69,50.34 54.69,52.14 54.08,52.74 54.08,52.78 53.69,53.16 53.69,53.54 53.76,53.61 54.5,53.61 54.62,53.73 54.62,53.98 54.63,53.99 54.63,54.53 54.7,54.61 54.9,54.61 55.03,54.47 55.37,54.47 55.8,54.91 56.06,55.17 56.46,55.17 56.77,54.86 56.77,54.59 56.2,54.02 56.2,53.74 56.53,53.4 56.94,53.4 v1(57.09,53.55)
  IN2 w0.102: v3(64.94,42.69) 64.3,42.69 64.22,42.61 63.23,42.61 63.19,42.56 61.24,42.56 60.84,42.16 60.5,42.16 60.29,41.95 58.53,41.95 58.03,42.45 57.21,42.45 56.85,42.81 56.14,42.81 v1(55.81,43.14) 55.55,43.14 55.48,43.22 55.33,43.22 54.91,42.79 54.88,42.79 54.88,42.78 54.56,42.78 54.53,42.81 53.09,42.81 52.66,42.38 51.28,42.38 51.07,42.18 49.21,42.18 48.61,42.79 46.73,42.79 v3(46.53,42.99)
  BOTTOM w0.089: U7.BH46 62.36,59.05 62.36,58.39 62.29,58.32 62.29,57.87 61.44,57.02 61.44,55.62 60.63,54.81 60.48,54.81 60.38,54.91 60.38,55.05 60.29,55.14 60.07,55.14 59.98,55.05 59.98,54.91 59.88,54.81 59.74,54.81 59.65,54.89 59.65,55.04 59.56,55.13 59.34,55.13 59.25,55.04 59.25,54.61 59.14,54.5 58.98,54.5 58.88,54.6 58.88,55.07 58.79,55.16 57.6,55.16 57.5,55.05 57.5,54.91 57.6,54.81 58.2,54.81 58.56,54.44 58.56,53.99 58,53.43 57.7,53.43 57.6,53.53 57.6,54 57.45,54.14 56.97,54.14 56.53,53.69 56.36,53.69 56.02,53.35 56.02,52.95 56.08,52.89 56.26,52.89 56.74,53.37 56.91,53.37 v1(57.09,53.55) ; v3(64.94,42.69) 64.94,42.91 65.06,43.04 65.71,43.04 65.89,43.22 65.89,43.6 66.12,43.83 66.46,43.83 66.54,43.9 66.71,43.9 66.83,43.78 66.83,43.46 66.74,43.37 U32.M2 ; U31.M2 48.77,43.37 48.87,43.46 48.87,43.66 48.78,43.75 48.2,43.75 48.11,43.66 48.11,43.22 47.91,43.02 47.7,43.02 47.65,42.97 47.47,42.97 47.41,42.91 46.6,42.91 v3(46.53,42.99)
M_A_BS1: length 73.6
  TOP w0.089: U24.N8 48.57,42.34 48.34,42.12 47.65,42.12 47.36,41.83 47.36,41.83 47.25,41.72 46.8,41.72 46.77,41.75 46.15,41.75 45.97,41.56 v3(45.97,41.47) ; 64.18,59.48 64.18,62.41 v1(64.58,62.81) ; v3(63.6,41.37) 64.04,41.82 64.45,41.82 64.75,42.12 65.31,42.12 65.41,42.22 66.22,42.22 66.35,42.34 U25.N8
  TOP w0.117: R1061.2 56.68,41.72 56.68,41.77 56.43,42.01 56.09,42.01 56.02,41.94 v1(55.18,41.94) 54.95,41.94 54.82,42.06 54.82,42.31 54.82,42.44 54.95,42.57 55.16,42.57 55.4,42.34 55.64,42.34 55.74,42.45 55.74,42.6 55.14,43.19 55.14,43.34 54.9,43.59 54.53,43.59 54.41,43.72 54.41,44.79 53.75,45.45 53.75,49.11 53.75,49.11 53.75,49.8 54.41,50.46 54.41,52.02 53.8,52.63 53.8,52.64 53.75,52.7 53.75,52.71 53.38,53.08 53.38,53.7 53.25,53.83 52.82,53.83 52.69,53.95 52.69,54.21 52.82,54.33 53.25,54.33 53.38,54.46 53.38,54.73 53.51,54.86 53.69,54.86 53.81,54.73 53.81,54.02 53.94,53.89 54.19,53.89 54.32,54.01 54.32,54.73 54.47,54.89 55.39,54.89 55.95,55.45 56.04,55.45 56.23,55.64 56.43,55.64 56.83,55.23 57.57,55.23 57.75,55.06 58.02,55.06 58.2,55.23 58.46,55.23 58.84,54.85 60.92,54.85 63.03,56.96 63.03,58.33 64.18,59.48
  IN2 w0.102: v3(63.6,41.37) 63.41,41.19 63.1,41.19 62.99,41.29 62.99,41.44 62.89,41.54 62.69,41.54 62.59,41.44 62.59,41.29 62.49,41.19 62.28,41.19 62.18,41.29 62.18,41.44 62.08,41.54 61.88,41.54 61.77,41.44 61.77,41.29 61.67,41.19 61.54,41.19 61.31,40.96 61.02,40.96 60.77,40.71 60.39,40.71 59.75,41.34 59.34,41.34 59.12,41.12 58.58,41.12 58.36,41.34 57.36,41.34 56.6,42.1 56.07,42.1 55.91,41.94 v1(55.18,41.94) 54.97,41.94 54.26,41.23 52.38,41.23 51.7,40.55 50.19,40.55 50.17,40.58 49.49,40.58 49.47,40.55 48.64,40.55 47.83,41.36 47.24,41.36 47.04,41.57 46.89,41.57 46.71,41.75 46.17,41.75 45.97,41.55 v3(45.97,41.47)
  BOTTOM w0.089: v3(45.97,41.47) 45.97,41.62 45.63,41.96 44.83,41.96 44.7,42.09 43.62,42.09 43.47,42.24 43.47,42.47 43.57,42.57 U31.N8 ; v3(63.6,41.37) 63.31,41.66 63.31,41.85 62.93,42.23 62.29,42.23 62.16,42.09 61.39,42.09 61.31,42.18 61.31,42.33 U32.N8 ; U7.AY40 v1(64.58,62.81)
M_A_BS2: length 69
  TOP w0.089: v3(45.93,43.14) 45.98,43.1 46.1,43.1 46.24,43.24 46.24,43.36 46.06,43.55 45.55,43.55 45.46,43.65 45.15,43.65 44.87,43.37 U24.M3 ; U25.M3 62.48,43.51 62.59,43.51 62.71,43.39 62.71,43.27 62.79,43.18 63.6,43.18 v3(63.77,43.36)
  IN1 w0.135: v1(50.86,43.12) 51.07,42.92 51.07,41.87 50.14,40.95 49.65,40.95 49.4,41.19 49.4,41.94 50.19,42.72 50.19,43.14 49.63,43.69 49.63,46.2 50.24,46.81 50.24,47.7 50.19,47.75 50.19,50.13 50.83,50.77 50.83,51.07 51.22,51.46 51.22,53.96 51.59,54.33 51.59,54.77 53.54,56.72 54.48,56.72 54.74,56.98 54.74,57.53 55.5,58.3 55.5,58.73 56.12,59.35 56.33,59.35 v1(56.83,58.84)
  IN2 w0.102: v3(45.93,43.14) 45.45,42.67 45.45,42.03 45.59,41.89 45.59,41.37 45.42,41.2 44.91,41.2 44.81,41.3 44.81,41.81 44.67,41.94 44.67,42.68 44.85,42.86 44.85,43.09 44.67,43.26 44.67,43.77 44.83,43.93 45.28,43.93 45.64,43.57 46.2,43.57 46.33,43.43 46.64,43.43 47.07,42.99 48.4,42.99 48.78,43.37 49.13,43.37 49.32,43.17 49.43,43.17 49.63,43.37 50.08,43.37 50.18,43.27 50.18,42.99 50.28,42.89 50.64,42.89 v1(50.86,43.12) 51.71,43.12 52.14,43.55 53.99,43.55 54.4,43.96 56.15,43.96 56.35,43.75 56.35,43.75 56.58,43.53 56.88,43.53 57.32,43.09 59.84,43.09 60.09,43.35 61.48,43.35 61.58,43.24 63.66,43.24 63.77,43.36 v3(63.77,43.36)
  BOTTOM w0.089: U31.M3 47.63,43.23 47.63,43.23 47.56,43.16 47.39,43.16 47.33,43.1 47.03,43.1 46.63,43.5 46.18,43.5 46.12,43.44 45.98,43.44 45.9,43.36 45.9,43.18 v3(45.93,43.14) ; v1(56.83,58.84) 56.83,59.25 57.34,59.75 58.1,59.75 58.44,60.09 58.94,60.09 59.16,59.87 U7.BF52 ; v3(63.77,43.36) 64.09,43.36 64.22,43.23 64.65,43.23 64.66,43.22 64.97,43.22 65.01,43.25 65.19,43.25 65.31,43.37 U32.M3
  BOTTOM w0.117: v1(50.86,43.12) 51.64,42.35 51.64,41.47 52.68,40.43 R1063.2
M_A_CAS#: length 61.8
  TOP w0.089: v3(46.48,45.27) 46.48,45.27 46.28,45.46 46.17,45.46 45.8,45.84 45.58,45.84 45.31,45.56 44.93,45.56 44.57,45.2 U24.K3 ; v3(63.74,45.71) 63.51,45.94 63.51,46.14 63.4,46.25 63.27,46.25 63.16,46.14 63.16,45.78 63.08,45.71 62.83,45.71 62.71,45.58 62.71,45.06 62.62,44.97 U25.K3
  IN1 w0.135: v1(56.29,46.38) 56.32,46.38 56.45,46.24 56.45,46.17 56.73,45.89 56.73,45.56 56.55,45.38 55.76,45.38 55.23,45.91 55.23,46.43 55.44,46.64 55.44,47.06 54.83,47.67 54.83,49.01 55.6,49.78 55.6,50.69 56.97,52.07 v1(56.97,52.67)
  IN2 w0.102: v3(63.74,45.71) 63.46,45.71 63.41,45.66 62.73,45.66 62.06,44.98 61.81,44.98 61.65,45.15 61.51,45.15 61.31,44.94 60.87,44.94 60.64,45.17 60.64,45.62 60.38,45.89 59.63,45.89 59.5,46.01 58.24,46.01 58.14,46.12 58.14,46.37 57.92,46.58 57.83,46.58 57.73,46.48 57.73,46.14 57.63,46.04 57.44,46.04 57.34,46.14 57.34,46.63 57.25,46.72 56.99,46.72 56.93,46.66 56.93,46.14 56.83,46.04 56.55,46.04 56.45,46.14 56.45,46.24 56.32,46.38 v1(56.29,46.38) 56.25,46.42 55.12,46.42 55.06,46.35 54.43,46.35 54.34,46.45 52.15,46.45 50.96,45.25 50.41,45.25 49.95,44.8 47.92,44.8 47.81,44.9 47.18,44.9 46.82,45.25 46.49,45.25 v3(46.48,45.27)
  BOTTOM w0.089: v1(56.97,52.67) 56.82,52.52 56.82,52.19 56.59,51.96 56.43,51.96 56.08,51.6 55.79,51.6 55.69,51.5 55.69,51.25 55.79,51.15 56.28,51.15 57.48,52.34 57.48,52.44 57.61,52.58 57.77,52.58 57.97,52.38 58.12,52.38 58.26,52.52 58.26,52.67 58.22,52.71 58.22,52.85 58.24,52.86 58.24,52.86 58.37,52.99 58.51,52.99 58.55,52.95 58.69,52.95 58.84,53.1 58.84,53.26 58.79,53.31 58.79,53.41 58.91,53.53 59.04,53.53 59.1,53.46 59.22,53.46 59.4,53.64 59.4,53.75 59.32,53.83 59.32,53.94 59.48,54.1 59.84,54.1 60.04,54.3 60.81,54.3 60.83,54.32 60.92,54.32 61.86,55.26 61.86,56.94 62.64,57.72 62.64,58.17 62.74,58.26 62.74,58.31 62.94,58.51 62.94,58.85 62.87,58.92 62.7,59.09 U7.BG45 ; U31.K3 47.66,45.07 47.66,45.41 47.56,45.52 47.42,45.52 47.27,45.37 47.1,45.37 47.01,45.46 47.01,45.76 46.93,45.84 46.8,45.84 46.72,45.76 46.72,45.48 46.51,45.27 v3(46.48,45.27) ; v3(63.74,45.71) 63.74,45.46 63.85,45.35 64.04,45.35 64.42,45.73 65.12,45.73 65.29,45.56 65.29,45.47 65.54,45.22 65.54,44.97 U32.K3
  BOTTOM w0.117: v1(56.29,46.38) 55.91,46.76 55.91,46.91 55.4,47.42 55.4,48.08 R1059.2
M_A_CKE0: length 76.8
  TOP w0.089: v3(45.26,45) 45.27,45 45.27,44.96 45.38,44.85 46.13,44.85 46.16,44.89 47.28,44.89 47.6,44.57 47.89,44.57 48,44.68 48.28,44.68 48.4,44.57 48.97,44.57 U24.K9 ; v3(64.85,44.77) 64.85,44.54 65.03,44.37 65.23,44.37 65.47,44.61 65.63,44.61 65.81,44.43 66.12,44.43 66.25,44.56 66.44,44.56 66.6,44.4 66.93,44.4 67.07,44.54 67.65,44.54 67.77,44.65 67.77,45.02 67.66,45.13 67.31,45.13 U25.K9
  IN1 w0.089: 62.36,57.45 62.41,57.5 62.41,58.56 63.41,59.56 63.76,59.56 64.05,59.85 64.05,62.21 63.57,62.69 v1(62.71,62.69)
  IN1 w0.135: v1(57.87,44.87) 58.58,44.16 59.58,44.16 60.03,44.62 60.03,45.66 58.38,47.31 57.24,47.31 56.65,47.9 56.37,47.9 56.08,48.19 56.08,49.23 56.32,49.46 56.32,50.16 57.32,51.16 58.06,51.16 58.32,51.42 58.32,51.79 57.53,52.57 57.53,54.23 58.15,54.85 58.3,54.85 58.74,55.29 60.89,55.29 61.77,56.17 61.77,56.86 62.36,57.45
  IN2 w0.102: v3(64.85,44.77) 64.84,44.84 64.71,44.97 64.51,44.97 64.39,44.86 64.14,44.86 63.87,45.13 63.5,45.13 63.42,45.2 62.88,45.2 62.19,44.52 61.98,44.52 61.86,44.39 61.72,44.39 61.59,44.52 60.88,44.52 60.74,44.38 60.59,44.38 60.45,44.52 60.33,44.52 60.23,44.62 60.23,45.36 60.11,45.48 59.46,45.48 59.33,45.61 58.17,45.61 58.07,45.51 58.07,45.36 58.25,45.18 58.7,45.18 58.79,45.1 58.79,44.83 58.71,44.75 58.43,44.75 58.32,44.64 58.32,44.3 58.16,44.13 57.72,44.13 57.43,44.42 57.43,44.54 57.6,44.71 57.72,44.71 v1(57.87,44.87) 57.23,45.51 56.79,45.51 56.76,45.54 56.25,45.54 56.22,45.51 55.18,45.51 55.09,45.6 51.88,45.6 51.13,44.85 50.79,44.85 50.33,44.39 47.75,44.39 47.65,44.49 46.92,44.49 46.73,44.69 45.58,44.69 v3(45.26,45)
  BOTTOM w0.089: v1(62.71,62.69) 62.89,62.52 U7.BB44 ; v3(45.26,45) 45.24,44.97 45.1,44.97 45.09,44.96 45.05,44.96 44.71,44.62 44.62,44.62 44.48,44.48 44.35,44.48 44.21,44.62 44.03,44.62 43.93,44.52 43.6,44.52 43.45,44.36 43.25,44.36 43.13,44.49 42.81,44.49 42.58,44.26 42.45,44.26 42.28,44.42 42.28,44.59 42.66,44.97 U31.K9
  BOTTOM w0.102: v3(64.85,44.77) 64.8,44.82 64.64,44.82 64.49,44.97 64.48,44.97 64.39,45.06 62.97,45.06 62.5,44.59 61.43,44.59 61.4,44.56 60.85,44.56 60.75,44.67 U32.K9
  BOTTOM w0.117: R1055.2 57.31,44.37 57.38,44.37 v1(57.87,44.87)
M_A_CLKN0: length 73.2
  TOP w0.089: v3(63.99,46.7) 64.19,46.89 64.36,46.89 64.45,46.79 64.45,46.55 64.61,46.4 64.61,46.21 64.81,46 64.92,46 64.99,45.93 64.99,45.49 65.22,45.27 65.46,45.27 65.55,45.18 U25.K7 ; U24.K7 47.5,45.23 47.22,45.23 46.73,45.72 46.73,45.79 46.71,45.82 46.71,46.3 46.71,46.3 46.71,46.33 46.73,46.35 46.73,46.81 46.63,46.92 46.54,46.92 v3(46.3,46.68)
  TOP w0.127: R1075.2 56.06,49.88 56.33,49.61 56.33,49.25 C750.1 56.24,48.79 56.24,48.34 56.66,47.91 v1(57.57,47.91)
  IN1 w0.089: v1(64.58,59.97) 64.76,60.15 64.93,60.15 64.99,60.09 64.99,59.68 64.86,59.55 64.41,59.55 64.12,59.25 64.12,58.98 63.93,58.8 63.76,58.8 63.73,58.83 63.44,58.83 63.01,58.4 63.01,57.25 62.97,57.21
  IN1 w0.14: v1(57.57,47.91) 57.39,48.1 56.96,48.1 56.63,48.43 56.63,48.94 56.97,49.27 56.97,50.03 57.49,50.55 58.02,50.55 58.33,50.24 58.33,49.58 58.52,49.39 58.77,49.39 58.91,49.53 58.91,50.26 59.17,50.52 59.59,50.52 60.02,50.1 60.82,50.1 61.07,50.35 61.07,50.6 60.73,50.94 60.73,51.36 61.08,51.72 61.08,51.92 60.94,52.06 60.6,52.06 60.29,52.37 60.29,53.46 60.15,53.6 59.76,53.6 59.47,53.32 59.47,52.45 59.18,52.16 58.72,52.16 58.1,52.77 58.1,53.53 59.28,54.71 60.84,54.71 61.55,54.01 61.77,54.01 62.06,54.29 62.06,54.49 61.7,54.85 61.7,55.27 62.03,55.6 62.5,55.6 62.72,55.37 62.92,55.37 63.06,55.51 63.06,55.82 62.61,56.28 62.61,56.76 62.97,57.12 62.97,57.21
  IN2 w0.102: v3(46.3,46.68) 46.45,46.82 46.62,46.82 46.74,46.71 46.77,46.71 46.94,46.54 47.7,46.54 47.89,46.35 47.91,46.35 47.95,46.3 50.11,46.3 51.13,47.32 52.03,48.22 57.27,48.22 v1(57.57,47.91) 57.87,48.21 58.09,48.21 58.37,48.49 58.37,50.13 58.53,50.28 59.1,50.28 59.25,50.13 59.25,49.91 58.9,49.56 58.9,47.36 59.19,47.07 60.1,47.07 60.5,46.66 60.86,46.31 63.07,46.31 63.58,46.82 63.87,46.82 v3(63.99,46.7)
  BOTTOM w0.076: v1(64.58,59.97) U7.BF40
  BOTTOM w0.089: v3(63.99,46.7) 63.8,46.89 63.71,46.89 63.59,46.78 63.59,46.43 63.14,45.98 62.99,45.98 62.9,45.89 62.9,45.49 62.67,45.27 62.43,45.27 62.35,45.18 U32.K7 ; U31.K7 44.57,45.19 44.65,45.28 44.92,45.28 45.13,45.49 45.28,45.49 45.63,45.83 45.63,46.43 46.04,46.84 46.14,46.84 v3(46.3,46.68)
M_A_CLKP0: length 73.1
  TOP w0.089: v3(64,47.28) 64.19,47.09 64.44,47.09 64.66,46.88 64.66,46.64 64.81,46.48 64.81,46.29 64.89,46.2 65,46.2 65.19,46.01 65.19,45.57 65.3,45.47 65.46,45.47 65.55,45.56 U25.J7 ; v3(46.3,47.26) 46.44,47.12 46.71,47.12 46.94,46.89 46.94,46.26 46.92,46.24 46.92,46.22 46.91,46.21 46.91,45.9 46.94,45.87 46.94,45.8 47.31,45.43 47.43,45.43 U24.J7
  TOP w0.127: v1(57.56,48.62) 57.56,48.5 57.2,48.14 56.76,48.14 56.51,48.39 56.51,48.55 56.83,48.87 C750.2 56.83,49.08 56.57,49.33 56.57,49.52 R1074.2
  IN1 w0.089: v1(64.58,60.68) 64.58,60.52 64.77,60.33 65.01,60.33 65.17,60.17 65.17,59.61 64.93,59.37 64.48,59.37 64.29,59.18 64.29,58.91 64.01,58.62 63.68,58.62 63.66,58.65 63.53,58.65 63.19,58.31 63.19,57.27 63.24,57.22 63.24,57.21
  IN1 w0.14: 63.24,57.21 63.24,57.01 62.87,56.65 62.87,56.39 63.33,55.94 63.33,55.4 63.03,55.1 62.61,55.1 62.39,55.33 62.14,55.33 61.97,55.16 61.97,54.96 62.32,54.6 62.32,54.18 61.88,53.74 61.44,53.74 60.73,54.44 59.39,54.44 58.37,53.42 58.37,52.88 58.83,52.42 59.07,52.42 59.21,52.56 59.21,53.43 59.65,53.87 60.26,53.87 60.55,53.58 60.55,52.48 60.71,52.33 61.05,52.33 61.35,52.03 61.35,51.61 60.99,51.25 60.99,51.05 61.34,50.71 61.34,50.24 60.93,49.83 59.91,49.83 59.48,50.26 59.28,50.26 59.18,50.15 59.18,49.42 58.88,49.13 58.41,49.13 58.07,49.47 58.07,50.13 57.91,50.28 57.6,50.28 57.23,49.92 57.23,49.16 56.9,48.83 56.9,48.54 57.07,48.37 57.31,48.37 v1(57.56,48.62)
  IN2 w0.102: v3(46.3,47.26) 46.52,47.04 46.73,47.04 46.85,46.92 46.88,46.92 47.03,46.77 47.79,46.77 47.99,46.57 48.04,46.52 50.02,46.52 51.87,48.37 51.94,48.43 57.38,48.43 v1(57.56,48.62) 57.56,48.6 57.73,48.43 58,48.43 58.15,48.58 58.15,50.22 58.43,50.5 59.19,50.5 59.47,50.22 59.47,49.82 59.12,49.47 59.12,47.45 59.28,47.28 60.19,47.28 60.66,46.82 60.95,46.52 62.98,46.52 63.28,46.83 63.49,47.04 63.75,47.04 v3(64,47.28)
  BOTTOM w0.076: U7.BD40 v1(64.58,60.68)
  BOTTOM w0.089: v3(64,47.28) 63.81,47.09 63.62,47.09 63.39,46.86 63.39,46.52 63.06,46.18 62.91,46.18 62.69,45.97 62.69,45.58 62.59,45.47 62.43,45.47 62.35,45.56 U32.J7 ; U31.J7 44.57,45.57 44.65,45.48 44.84,45.48 45.05,45.69 45.2,45.69 45.42,45.91 45.42,46.52 45.95,47.05 46.09,47.05 v3(46.3,47.26)
M_A_CLKP0_N0_C: length 5.9
  TOP w0.102: R1075.1 R1074.1 57.42,50.65 58.14,49.94 58.14,47.78 57.75,47.39 C749.2
M_A_CS#0: length 82.7
  TOP w0.089: v3(45.81,44.01) 45.64,43.84 45.07,43.84 44.94,43.71 44.41,43.71 44.21,43.91 44.08,43.91 43.9,43.73 43.67,43.73 43.44,43.5 43.32,43.5 43.12,43.7 43.12,43.86 43.29,44.03 43.29,44.31 43.35,44.38 43.69,44.38 43.77,44.3 ; 65.71,59.55 65.84,59.55 65.97,59.68 65.97,63.44 65.88,63.53 v1(65.57,63.53) ; U25.L2 61.34,44.37 61.14,44.37 61.07,44.31 61.07,44.03 60.88,43.84 60.88,43.69 61.06,43.51 61.22,43.51 61.46,43.75 61.68,43.75 61.9,43.97 62.03,43.97 62.18,43.81 62.55,43.81 62.99,43.37 63.23,43.37 63.35,43.49 63.35,43.58 v3(63.06,43.88)
  TOP w0.094: U24.L2 43.77,44.3
  TOP w0.117: 65.71,59.55 65.24,59.55 64.34,58.64 64.34,58.46 64.67,58.13 64.88,58.13 65.33,58.58 67.84,58.58 67.97,58.45 67.97,57.78 67.75,57.57 67.32,57.57 66.78,58.11 66.26,58.11 65.74,57.59 64.63,57.59 64.22,57.17 64.05,57.17 63.89,57.34 63.72,57.34 63.59,57.21 63.59,56.97 63.72,56.84 63.72,56.68 61.09,54.04 60.86,54.04 60.62,54.28 60,54.28 59.86,54.14 59.86,54.02 59.76,53.91 59.46,53.91 59.35,54.02 59.35,54.15 59.24,54.27 58.83,54.27 57.53,52.97 57.53,52.37 57.1,51.94 56.34,51.94 55.99,51.59 55.46,51.59 55.25,51.38 55.25,50.11 54.58,49.44 54.58,48.57 54.69,48.45 54.8,48.45 54.91,48.34 54.91,48.1 54.8,47.99 54.69,47.99 54.58,47.87 54.58,47.35 54.71,47.22 54.92,47.22 55.29,47.58 55.46,47.58 55.57,47.47 55.57,46.85 55.1,46.38 54.9,46.38 54.66,46.15 54.66,45.69 54.97,45.38 54.97,44.3 55.43,43.83 55.67,43.83 56.08,44.24 56.08,44.5 55.94,44.64 v1(55.44,44.64)
  IN2 w0.102: v3(63.06,43.88) 63.13,43.95 63.13,44.12 62.94,44.31 62.85,44.31 62.57,44.03 62.57,43.75 62.47,43.65 62.32,43.65 62.22,43.75 62.05,43.75 61.95,43.65 61.82,43.65 61.71,43.75 61.49,43.75 61.34,43.91 61.18,43.91 61.03,43.75 60.22,43.75 60.09,43.88 59.88,43.88 59.76,43.76 59.76,43.59 59.7,43.53 59.42,43.53 59.32,43.63 59.32,43.79 59.4,43.87 59.4,44.01 59.29,44.13 59.01,44.13 58.87,43.98 58.87,43.65 58.74,43.53 57.46,43.53 57.05,43.93 56.76,43.93 56.33,44.36 56.09,44.36 56,44.46 56,44.8 55.9,44.9 55.54,44.9 55.44,44.8 v1(55.44,44.64) 55.38,44.7 55.03,44.7 54.73,44.4 54.49,44.4 54.39,44.5 54.39,44.8 54.29,44.9 54.16,44.9 54.11,44.95 52.09,44.95 51.38,44.24 51.17,44.24 50.71,43.78 47.5,43.78 47.39,43.88 47.01,43.88 46.8,43.67 46.38,43.67 46.28,43.77 45.91,43.77 45.81,43.87 v3(45.81,44.01)
  BOTTOM w0.089: v3(45.81,44.01) 45.64,44.17 45.64,44.3 45.81,44.46 46.13,44.46 46.2,44.4 46.2,44.15 46.22,44.13 46.22,44.05 46.36,43.91 46.8,43.91 47.05,44.16 47.28,44.16 47.71,43.74 47.9,43.74 48.12,43.96 48.12,44.26 48.21,44.35 48.38,44.35 U31.L2 ; v3(63.06,43.88) 63.36,43.88 63.45,43.97 63.97,43.97 64.09,44.09 64.37,44.09 64.48,44.2 64.61,44.2 64.85,43.97 64.97,43.97 65.26,43.68 65.4,43.68 65.41,43.69 65.72,43.69 65.86,43.83 65.86,43.91 65.96,44.02 65.96,44.18 65.88,44.26 65.87,44.26 65.87,44.38 65.96,44.46 66.08,44.46 66.12,44.43 66.26,44.43 66.35,44.34 U32.L2 ; U7.AY38 v1(65.57,63.53)
  BOTTOM w0.117: R1054.2 55.98,44.1 v1(55.44,44.64)
M_A_DM0: length 40.9
  IN2 w0.089: v3(44.98,48.62) 44.97,48.63
  IN2 w0.107: v1(54.92,64.57) 54.92,64.18 54.81,64.07 54.35,64.07 54.25,63.97 54.25,63.67 54.14,63.57 53.94,63.57 53.84,63.67 53.84,63.97 53.74,64.07 53.53,64.07 53.43,63.97 53.43,63.68 53.32,63.57 53.13,63.57 53.03,63.68 53.03,63.97 52.92,64.07 52.59,64.07 52.49,63.97 52.49,63.95 52.39,63.85 52.19,63.85 52.09,63.95 52.09,63.97 51.98,64.07 51.22,64.07 47.15,60.01 46.1,60.01 44,57.91 43.85,57.91 43.8,57.96 43.66,57.96 43.51,57.81 43.51,57.67 43.56,57.62 43.56,57.48 43.4,57.32 43.4,57.17 43.48,57.1 43.48,56.95 43.33,56.81 43.19,56.81 42.97,57.03 42.83,57.03 42.7,56.9 42.7,56.73 42.9,56.52 42.9,56.38 42.76,56.23 42.61,56.23 42.37,56.48 42.22,56.48 41.99,56.25 41.99,56.1 42.24,55.85 42.24,55.72 42.2,55.68 42.2,55.67 42.1,55.56 41.95,55.56 41.78,55.74 41.64,55.74 41.47,55.57 41.47,54.93 41.57,54.83 42.1,54.83 42.2,54.73 42.2,54.53 42.1,54.43 41.57,54.43 41.47,54.33 41.47,54.12 41.57,54.02 42.1,54.02 42.2,53.92 42.2,53.72 42.1,53.61 41.57,53.61 41.47,53.52 41.47,53.31 41.57,53.21 42.1,53.21 42.2,53.11 42.2,52.9 42.1,52.8 41.57,52.8 41.47,52.7 41.47,52.43 41.82,52.09 41.82,51.31 41.97,51.16 42.27,51.16 42.38,51.04 42.38,50.39 42.48,50.28 42.9,50.28 43.32,49.87 44.29,49.87 44.74,49.42 44.74,49.1 44.97,48.87 44.97,48.63
  BOTTOM w0.089: U31.E7 44.63,48.97
  BOTTOM w0.094: v1(54.92,64.57) 54.92,65.33 55.06,65.47 55.23,65.47 55.33,65.37 55.33,65.19 55.44,65.09 55.64,65.09 55.74,65.19 55.74,65.37 55.84,65.47 56.16,65.47 56.87,66.19 58.72,66.19 58.78,66.13 U7.AP52 ; 44.63,48.97 v3(44.98,48.62)
M_A_DM1: length 38.7
  TOP w0.094: v3(46.14,48.41) 46.63,48.41 46.85,48.63 46.85,48.88 47.18,49.22 47.51,49.22 U24.E7
  IN1 w0.089: v3(46.14,48.41) 45.95,48.61 45.56,48.61 45.24,48.29 45.24,47.59 45.08,47.44 44.65,47.44 44.55,47.54 44.55,49.52 44.3,49.76 44.04,49.76 ; v1(60.58,64.67) 60.18,64.26 58.8,64.26 58.52,63.98 57.72,63.98
  IN1 w0.107: 57.72,63.98 57.58,64.12 51.58,64.12 51.5,64.2 48.58,64.2 42.33,57.95 42.33,54.84 42.18,54.68 42.18,52.85 42.03,52.7 42.02,52.7 41.78,52.46 41.78,52.46 41.78,52.02 42.84,50.97 42.84,50.74 43.76,49.82 43.98,49.82 44.04,49.76
  BOTTOM w0.089: v1(60.58,64.67) U7.AT48
M_A_DM2: length 38.7
  IN2 w0.089: 58.72,65.12 59.66,66.06 62.31,66.06 v1(62.71,65.66)
  IN2 w0.107: v3(46.88,51.3) 46.47,51.71 46.47,53.02 47.2,53.76 47.2,54.1 47.2,54.41 47.42,54.63 47.42,55.4 47.97,55.95 47.97,56.71 48.07,56.81 48.28,56.81 48.38,56.71 48.38,55.79 48.47,55.69 48.69,55.69 48.78,55.79 48.78,56.71 48.89,56.81 49.09,56.81 49.19,56.71 49.19,55.79 49.29,55.69 49.5,55.69 49.6,55.79 49.6,56.71 49.7,56.81 49.9,56.81 50,56.71 50,55.79 50.1,55.69 50.44,55.69 50.44,55.69 50.79,55.69 50.89,55.79 50.89,55.89 50.99,56 51.2,56 51.3,55.89 51.3,55.8 51.4,55.7 54.63,55.7 55.16,56.23 55.31,56.23 55.71,55.83 55.85,55.83 56,55.97 56,56.12 55.59,56.52 55.59,56.66 55.8,56.87 55.8,57.04 55.82,57.06 55.82,57.06 56.4,57.65 56.4,57.72 56.4,60.34 56.5,60.44 56.73,60.44 56.83,60.54 56.83,60.74 56.72,60.85 56.5,60.85 56.4,60.95 56.4,61.61 56.4,62.09 58.72,64.41 58.72,65.12
  BOTTOM w0.089: U7.AP44 62.9,65.91 62.82,65.81 v1(62.71,65.66)
  BOTTOM w0.094: v3(46.88,51.3) 46.88,50.03 47.14,49.77 47.76,49.77 U31.D3
M_A_DM3: length 21.4
  TOP w0.094: U24.D3 44.93,49.77 45.48,50.32 45.48,51.39 46.47,52.38 46.47,53.74 v3(47.82,55.08)
  IN1 w0.089: v1(54.88,60.01) 53.81,58.95 51.86,58.95 51.77,58.85
  IN1 w0.107: 51.77,58.85 51.05,58.85 50.36,58.16 50.36,57.94 49.84,57.42 49.62,57.42 49.13,56.93 49.13,56.6 48.59,56.06 48.26,56.06 47.98,55.78 47.98,55.25 v3(47.82,55.08)
  BOTTOM w0.094: v1(54.88,60.01) 55.34,60.47 55.62,60.47 57.87,62.73 U7.BA53
M_A_DM4: length 12.4
  BOTTOM w0.089: U7.BG41 65.16,59.43 65.45,59.72 65.69,59.72 65.86,59.55 65.86,59.28 65.77,59.19 65.77,58.94 65.84,58.87 65.84,58.39 65.96,58.27 65.96,57.92 65.39,57.35
  BOTTOM w0.094: U32.D3 65.55,49.9 64.5,50.95 64.5,55.17 64.97,55.64 64.97,56.43 65.39,56.86 65.39,57.35
M_A_DM5: length 25.3
  TOP w0.094: v3(64.05,52.14) 63.95,52.03 63.95,50.07 64.43,49.59 64.43,49.28 64.6,49.11 65.4,49.11 U25.E7
  IN1 w0.094: 66.31,58.59 67.2,59.48 67.2,63.06 66.99,63.26 66.99,63.62 67.2,63.82 67.2,64.08 66.96,64.32 66.96,64.72 67.28,65.05 67.28,65.22 67.13,65.37 66.91,65.37 66.8,65.26 66.07,65.26 65.98,65.16 65.98,65 66.24,64.74 66.24,64.61 65.98,64.35 65.98,63.74 66.13,63.59 66.13,63.26 65.94,63.07 65.94,62.8 66.1,62.64 66.38,62.64 v1(66.56,62.81)
  IN1 w0.107: v3(64.05,52.14) 64.28,51.91 64.66,51.91 64.99,52.24 64.99,53.83 65.12,53.96 65.12,56.54 65.13,56.55 65.13,56.62 66.31,57.8 66.31,58.59
  BOTTOM w0.089: U7.AY36 v1(66.56,62.81)
M_A_DM6: length 21.4
  IN2 w0.089: 68.55,58.5 69.86,59.8 69.86,60.28 v1(69.46,60.68)
  IN2 w0.107: 68.55,58.5 68.55,57.45 67.8,56.71 67.8,54.01 67.6,53.81 66.42,53.81 66.12,53.51 66.12,52.92 65.87,52.67 65.7,52.67 65.59,52.79 65.42,52.79 65.32,52.68 65.32,52.48 65.43,52.36 65.43,52.2 65.39,52.16 65.39,52.01 65.53,51.88 65.67,51.88 65.72,51.93 66.01,51.93 66.38,52.3 66.53,52.3 66.67,52.16 66.67,52.02 66.3,51.64 66.3,51.5 66.32,51.48 66.32,51.33 66.18,51.19 66.03,51.19 65.83,51.39 65.64,51.39 65.54,51.29 65.54,51.11 65.74,50.9 65.74,50.76 65.6,50.62 65.46,50.62 65.3,50.78 65.15,50.78 65,50.62 65,50.48 65.07,50.41 65.07,50.26 64.86,50.05 v3(64.84,50.05)
  BOTTOM w0.089: 69,61.01 v1(69.46,60.68)
  BOTTOM w0.094: U7.BD32 69,61.01 ; v3(64.84,50.05) 64.81,50.03 64.02,50.03 63.52,49.53 63.52,49.3 63.28,49.06 62.44,49.06 U32.E7
M_A_DM7: length 14
  TOP w0.094: U25.D3 62.66,50.08 62.66,50.08 63.72,51.14 63.72,51.82 63.64,51.89 63.64,52.3 63.88,52.54 63.95,52.54 65.19,53.79 66.36,53.79 66.49,53.91 67.14,53.91 67.19,53.86 67.51,53.86 67.81,54.16 67.81,55.13 68.64,55.97 68.64,56.45 v1(69.53,57.34)
  BOTTOM w0.089: U7.BH30 69.88,59 69.88,58.25 69.95,58.17 69.95,57.76
  BOTTOM w0.094: 69.95,57.76 v1(69.53,57.34)
M_A_DQ0: length 40.8
  IN2 w0.089: v3(45.05,46.22) 44.93,46.33 44.93,46.48 44.61,46.8 44.61,47.12 44.37,47.36 43.93,47.36
  IN2 w0.107: v1(53.1,66.74) 52.7,66.33 50.98,66.33 49.94,65.29 49.87,65.29 46.39,61.81 45.24,61.81 39.43,56.01 39.43,48.33 40.73,47.03 43.6,47.03 43.93,47.36
  BOTTOM w0.094: U31.H7 44.7,46.57 v3(45.05,46.22) ; v1(53.1,66.74) 53.79,67.43 54.35,67.43 54.94,68.01 56.94,68.01 57.08,68.14 58.19,68.14 58.32,68.27 58.75,68.27 58.85,68.37 59.09,68.37 59.39,68.07 U7.AK51
M_A_DQ1: length 40
  IN2 w0.089: 43.53,47.41 43.53,47.41 43.75,47.63 43.75,47.89 43.99,48.12 44.31,48.12 44.55,47.88 44.55,47.49 45,47.05 v3(45,46.95)
  IN2 w0.107: 43.53,47.41 43.42,47.3 41.12,47.3 40.35,48.07 40.35,50.81 40.17,51 40.17,56.35 45.33,61.51 46.62,61.51 51.17,66.05 52.85,66.05 53.12,66.33 54.02,66.33 v1(54.41,66.72)
  BOTTOM w0.094: v1(54.41,66.72) 55.13,67.44 57.2,67.44 57.5,67.74 58.31,67.74 58.45,67.88 58.74,67.88 59.03,67.58 U7.AL51 ; v3(45,46.95) 45,47.74 U31.F7
M_A_DQ2: length 39.5
  IN2 w0.089: v3(48.97,48.57) 48.58,48.96 48.58,49.49 48.32,49.75 47.25,49.75
  IN2 w0.107: 47.25,49.75 46.91,50.09 46.52,50.09 46.06,50.55 45.24,50.55 44.13,51.65 44.13,51.95 44.13,51.95 44.13,55.31 44.45,55.62 44.45,55.77 44.29,55.93 44.29,56.08 44.43,56.22 44.58,56.22 44.74,56.06 44.88,56.06 47.12,58.3 50.73,58.3 51.14,58.71 51.14,59.53 51.03,59.64 50.84,59.84 50.84,59.84 50.84,60.24 51.02,60.42 51.32,60.42 51.42,60.52 51.42,60.72 51.52,60.82 51.73,60.82 51.83,60.72 51.83,60.53 51.93,60.42 52.13,60.42 52.24,60.53 52.24,60.72 52.34,60.82 52.54,60.82 52.64,60.72 52.64,60.52 52.74,60.42 53.07,60.42 53.18,60.52 53.18,60.67 53.28,60.77 53.48,60.77 53.58,60.67 53.58,60.52 53.68,60.42 54.06,60.42 54.19,60.54 54.19,61.02 54.06,61.15 51.69,61.15 51.56,61.28 51.56,61.7 51.89,62.03 54.42,62.03 54.52,62.13 v1(54.52,63.16)
  BOTTOM w0.089: U31.F2 48.57,48.17 v3(48.97,48.57)
  BOTTOM w0.094: U7.AT52 58.79,65.16 58.72,65.09 57.36,65.09 55.43,63.16 v1(54.52,63.16)
M_A_DQ3: length 42.7
  IN2 w0.089: v3(47.29,48.72) 47.29,48.38 47.37,48.3 47.56,48.3 47.77,48.51 47.77,49.31 47.66,49.42 47.26,49.42 46.83,48.99 46.64,48.99 46.45,49.17 45.68,49.17 45.5,49.34
  IN2 w0.107: 45.5,49.34 45.5,49.71 44.65,50.56 43.74,50.56 43.52,50.78 43.52,51.35 43.78,51.61 43.78,52.1 43.75,52.14 43.75,52.5 43.65,52.6 43.55,52.6 43.45,52.7 43.45,52.91 43.55,53.01 43.65,53.01 43.75,53.11 43.75,53.31 43.65,53.42 43.55,53.42 43.45,53.52 43.45,53.72 43.55,53.82 43.65,53.82 43.75,53.92 43.75,54.13 43.65,54.23 43.55,54.23 43.45,54.33 43.45,54.53 43.55,54.64 43.65,54.64 43.75,54.74 43.75,54.94 43.65,55.04 43.55,55.04 43.45,55.14 43.45,55.35 43.55,55.45 43.65,55.45 43.75,55.55 43.75,55.97 44.48,56.7 44.62,56.7 44.71,56.61 44.85,56.61 44.99,56.76 44.99,56.9 44.91,56.98 44.91,57.13 45.05,57.27 45.2,57.27 45.28,57.19 45.42,57.19 45.57,57.33 45.57,57.47 45.48,57.56 45.48,57.7 45.63,57.85 45.77,57.85 45.86,57.76 46,57.76 46.14,57.91 46.14,58.05 46.06,58.13 46.06,58.28 46.2,58.42 46.35,58.42 46.43,58.34 46.57,58.34 46.72,58.48 46.72,58.62 46.63,58.71 46.63,58.85 46.8,59.02 47.28,59.02 47.38,58.92 47.38,58.68 47.49,58.58 47.69,58.58 47.79,58.68 47.79,58.92 47.89,59.02 48.1,59.02 48.2,58.92 48.2,58.68 48.3,58.58 48.5,58.58 48.6,58.68 48.6,58.92 48.71,59.02 48.91,59.02 49.01,58.92 49.01,58.68 49.11,58.58 49.31,58.58 49.42,58.68 49.42,58.92 49.52,59.02 49.72,59.02 49.82,58.92 49.82,58.68 49.92,58.58 50.13,58.58 50.23,58.68 50.23,58.92 50.33,59.02 50.76,59.02 50.86,59.12 50.86,59.42 50.84,59.45 50.56,59.73 50.56,60.9 50.66,61 50.83,61 50.9,60.93 51.04,60.93 51.19,61.07 51.19,61.21 51.01,61.39 51.01,61.54 51.78,62.31 52.31,62.31 52.41,62.41 52.41,62.65 52.51,62.75 52.71,62.75 52.81,62.65 52.81,62.41 52.91,62.31 53.12,62.31 53.22,62.41 53.22,62.65 53.32,62.75 53.52,62.75 53.63,62.65 53.63,62.41 53.73,62.31 54.06,62.31 54.17,62.41 54.17,62.8 v1(53.81,63.16)
  BOTTOM w0.089: 47.3,48.73 47.54,48.97 U31.E3
  BOTTOM w0.094: v1(53.81,63.16) 54.24,63.59 55.48,63.59 57.23,65.34 58.74,65.34 58.85,65.45 59.14,65.45 U7.AR51 ; 47.3,48.73 v3(47.29,48.72)
M_A_DQ4: length 40.8
  IN2 w0.089: v3(43.37,47.79) 42.99,47.79 42.67,48.11 42.11,48.11
  IN2 w0.094: 53.17,65.78 53.65,65.78 53.75,65.67
  IN2 w0.107: 53.75,65.67 53.75,65.19 53.86,65.09 54.06,65.09 54.16,65.19 54.16,65.67 54.26,65.78 54.59,65.78 54.69,65.67 54.69,65.19 54.79,65.09 55.18,65.09 55.28,65.19 55.28,65.5 55.39,65.6 56.07,65.6 56.2,65.72 56.2,66 56.1,66.11 55.39,66.11 55.28,66.21 v1(55.28,66.74) ; 53.17,65.78 53.17,65.78 51.32,65.78 46.74,61.19 45.44,61.19 45.34,61.09 45.34,61.09 40.45,56.2 40.45,51.2 40.7,50.94 40.7,49.67 40.81,49.57 41.24,49.57 41.34,49.46 41.34,49.26 41.24,49.16 40.81,49.16 40.7,49.06 40.7,48.33 40.84,48.19 41.43,48.19 41.53,48.29 41.53,48.73 41.63,48.83 41.83,48.83 41.94,48.73 41.94,48.29 42.11,48.11
  BOTTOM w0.089: 43.56,47.98 43.75,48.17 U31.F8
  BOTTOM w0.094: U7.AL53 58.5,67.5 57.6,67.5 57.27,67.17 55.72,67.17 v1(55.28,66.74) ; 43.56,47.98 v3(43.37,47.79)
M_A_DQ5: length 38.7
  IN2 w0.107: v1(53.76,66.74) 53.35,67.15 52.77,67.15 52.24,66.61 50.86,66.61 49.82,65.57 49.75,65.57 46.32,62.14 45.16,62.14 39.15,56.14 39.15,48.17 41.21,46.12 42.84,46.12 42.93,46.21 v3(43.37,46.21)
  BOTTOM w0.094: v3(43.37,46.21) 43.73,46.57 U31.H8 ; U7.AK52 58.38,68.07 58.25,67.94 57.3,67.94 57.08,67.72 54.98,67.72 54.38,67.12 54.15,67.12 v1(53.76,66.74)
M_A_DQ6: length 42.5
  IN2 w0.089: 43.45,50.09 44.47,50.09 44.94,49.62 44.94,49.26 45.41,48.79 46.3,48.79 46.52,48.57 46.52,48.13 46.43,48.04 46.19,48.04 46.1,47.95 46.1,47.73 46.19,47.64 46.45,47.64 46.59,47.5 46.8,47.5 v3(47,47.71)
  IN2 w0.107: v1(52.39,63.16) 52.39,63.44 52.27,63.55 52,63.55 51.75,63.79 51.33,63.79 50.94,63.4 50.94,63.26 51.22,62.97 51.22,62.83 51.09,62.7 50.92,62.7 50.65,62.97 50.51,62.97 50.32,62.78 50.32,62.64 50.74,62.21 50.74,62.07 50.6,61.92 50.46,61.92 50.03,62.35 49.89,62.35 49.74,62.2 49.74,62.06 50.17,61.63 50.17,61.49 50.02,61.35 49.88,61.35 49.45,61.77 49.31,61.77 49.17,61.63 49.17,61.49 49.62,61.03 49.62,60.89 49.47,60.75 49.33,60.75 48.88,61.2 48.74,61.2 48.59,61.05 48.59,60.91 49.12,60.38 49.12,60.24 49,60.12 48.81,60.12 48.3,60.62 48.16,60.62 47.27,59.73 46.32,59.73 43.75,57.17 43.75,56.84 43.63,56.71 42.48,55.56 42.48,52.61 42.73,52.36 42.73,52.18 42.36,51.81 42.36,51.6 42.76,51.2 42.76,50.78 43.45,50.09
  BOTTOM w0.094: v1(52.39,63.16) 52.39,63.57 52.69,63.87 55.37,63.87 57.14,65.64 U7.AR53 ; v3(47,47.71) 46.93,47.63 46.93,47.61 46.8,47.49 46.8,46.9 46.93,46.77 47.46,46.77 47.67,46.57 U31.H3
M_A_DQ7: length 44.1
  IN2 w0.089: v3(48.97,47.77) 48.97,47.43 49.04,47.36 49.31,47.36 49.39,47.44 49.39,48.02 49.25,48.16 47.85,48.16 47.78,48.08 47.78,47.49 47.7,47.41 47.5,47.41 47.42,47.49 47.42,47.96 47.29,48.09 46.81,48.09 46.71,48.19 46.71,48.65 46.38,48.98 45.49,48.98 45.24,49.23 45.24,49.6 44.81,50.03
  IN2 w0.107: 44.81,50.03 44.55,50.29 43.63,50.29 43.09,50.83 43.09,51.3 42.81,51.58 42.81,51.78 43.09,52.06 43.09,52.59 42.99,52.69 42.86,52.69 42.76,52.79 42.76,52.99 42.86,53.09 42.99,53.09 43.09,53.19 43.09,53.4 42.99,53.5 42.86,53.5 42.76,53.6 42.76,53.8 42.86,53.91 42.99,53.91 43.09,54.01 43.09,54.21 42.99,54.31 42.86,54.31 42.76,54.41 42.76,54.62 42.86,54.72 42.99,54.72 43.09,54.82 43.09,55.02 42.99,55.13 42.86,55.13 42.76,55.23 42.76,55.43 42.86,55.53 42.99,55.53 43.09,55.63 43.09,55.78 43.9,56.59 44.03,56.72 44.03,56.96 44.67,57.6 44.81,57.6 44.86,57.55 45,57.55 45.14,57.69 45.14,57.84 45.1,57.88 45.1,58.03 45.27,58.2 45.41,58.2 45.47,58.14 45.62,58.14 45.76,58.28 45.76,58.43 45.7,58.49 45.7,58.63 45.86,58.79 46,58.79 46.06,58.73 46.21,58.73 46.35,58.88 46.35,59.02 46.29,59.08 46.29,59.22 46.52,59.45 47.02,59.45 47.18,59.3 47.43,59.3 47.74,59.61 47.89,59.61 48.2,59.3 48.84,59.3 48.94,59.4 48.94,59.53 49.04,59.63 49.24,59.63 49.35,59.53 49.35,59.4 49.45,59.3 50.18,59.3 50.28,59.4 50.28,59.88 50.18,59.98 49.57,59.98 49.47,60.09 49.47,60.29 49.57,60.39 50.18,60.39 50.28,60.49 50.28,61.21 51.66,62.59 51.66,63.14 v1(51.68,63.16)
  BOTTOM w0.089: U31.G2 48.57,47.37
  BOTTOM w0.094: U7.AP51 59.39,66.13 59.27,66 59.09,65.83 58.85,65.83 58.75,65.93 57.03,65.93 55.26,64.15 51.96,64.15 51.68,63.87 v1(51.68,63.16) ; 48.57,47.37 v3(48.97,47.77)
M_A_DQ8: length 38
  TOP w0.089: U24.H3 44.57,46.55
  TOP w0.094: 44.57,46.55 v3(44.18,46.17)
  IN1 w0.089: 56.58,65.34 59,65.34 59.47,65.82 59.47,65.83 59.7,66.06 60.18,66.06 v1(60.58,65.66)
  IN1 w0.102: 56.58,65.34 56.27,65.34 56.08,65.54
  IN1 w0.107: 56.08,65.54 55.99,65.63 55.11,65.63 55.02,65.53 51.63,65.53 51.62,65.53 51.61,65.53 51.22,65.13 48.33,65.13 40.63,57.43 40.63,51.2 40.83,50.99 40.83,49.65 42.36,48.12 42.67,48.12 42.9,47.9 42.9,47.89 42.9,47.45 v3(44.18,46.17)
  BOTTOM w0.089: v1(60.58,65.66) 60.69,65.81 U7.AP48
M_A_DQ9: length 39.1
  TOP w0.094: U24.E3 44.56,48.97 v3(44.16,49.37)
  IN1 w0.089: v3(44.16,49.37) 44.13,49.34 ; 56.09,64.73 56.12,64.71 57.34,64.71 57.87,64.18 58.24,64.18 58.71,64.64 59.28,64.64 59.85,65.22 60.74,65.22 v1(61.29,64.67)
  IN1 w0.107: 44.13,49.34 43.75,48.96 43.1,48.96 42.97,49.09 42.97,49.36 42.87,49.46 42.73,49.46 42.62,49.57 42.62,49.74 42.73,49.85 42.99,49.85 43.09,49.95 43.09,50.1 42.81,50.38 42.62,50.38 42.41,50.16 42.25,50.16 42.03,50.39 41.83,50.39 41.61,50.61 41.61,50.93 41.61,50.93 41.61,51.61 41.29,51.93 41.29,52.36 41.9,52.97 41.9,53.21 41.79,53.32 41.68,53.32 41.59,53.42 41.59,53.64 41.68,53.74 41.82,53.74 41.9,53.81 41.9,54.34 41.8,54.44 41.69,54.44 41.59,54.54 41.59,54.95 41.69,55.05 41.95,55.05 42.05,55.15 42.05,55.36 41.95,55.46 41.69,55.46 41.59,55.56 41.59,56.23 41.69,56.33 41.9,56.33 42,56.44 42,56.64 41.9,56.74 41.69,56.74 41.59,56.84 41.59,57.06 42.05,57.52 42.05,58.06 48.47,64.48 51.4,64.48 51.61,64.69 51.61,64.73 51.86,64.98 55.35,64.98 55.45,65.08 55.74,65.08 55.83,64.98 55.85,64.98 56.09,64.73
  BOTTOM w0.089: v1(61.29,64.67) U7.AT47
M_A_DQ10: length 32.4
  TOP w0.089: v3(48.17,48.57) 48.57,48.17 U24.F8
  IN1 w0.089: 46.05,50.88 46.05,50.77 46.38,50.43 46.5,50.43 47.33,49.6 47.56,49.6 47.69,49.47 47.69,49.28 47.88,49.09 47.88,48.85 v3(48.17,48.57) ; v1(61.29,62.69) 61.29,62.2 61.19,62.1 59.48,62.1 59.3,61.91 57.62,61.91 56.63,60.92 55.51,60.92 55.28,61.15 55.28,61.75 55.05,61.99 51.28,61.99
  IN1 w0.107: 46.05,50.88 45.31,51.62 45.19,51.62 44.84,51.97 44.84,52.19 44.28,52.75 44.28,56.98 49.13,61.83 51.12,61.83 51.28,61.99
  BOTTOM w0.089: U7.AY48 61.22,62.79 v1(61.29,62.69)
M_A_DQ11: length 34.1
  TOP w0.094: U24.H7 47.51,46.83 47.5,46.83 47.22,47.11 v3(47.22,47.15)
  IN1 w0.089: 44.58,50.17 44.58,50.08 44.58,50.08 44.58,50.06 45.58,49.06 46.33,49.06 47.39,48 47.39,47.32 v3(47.22,47.15) ; 57.6,63.44 59.13,63.44 59.37,63.68 v1(59.87,63.68)
  IN1 w0.107: 57.6,63.44 57.46,63.57 51.34,63.57 51.27,63.64 49.7,63.64 49.7,63.64 49,63.64 42.91,57.55 42.91,51.68 42.98,51.61 42.98,51.61 43.21,51.38 43.21,51.38 43.38,51.21 43.38,51.05 44,50.43 44.31,50.43 44.58,50.17
  BOTTOM w0.089: U7.AV50 v1(59.87,63.68)
M_A_DQ12: length 38.4
  TOP w0.089: U24.G2 43.77,47.34
  TOP w0.094: v3(41.91,47.74) 42.2,47.45 42.2,47.39 42.53,47.06 42.77,47.06 42.82,47.01 43.35,47.01 43.45,47.12 43.54,47.12 43.77,47.34
  IN1 w0.089: v1(61.29,65.66) 61.13,65.83 61.12,65.83 60.71,66.23 60.26,66.23 60.25,66.24 59.63,66.24 59.62,66.23 59.33,66.23 58.92,65.83 58.92,65.83 58.76,65.67 56.33,65.67
  IN1 w0.107: 56.33,65.67 56.1,65.9 55,65.9 54.91,65.8 51.52,65.8 51.51,65.8 51.5,65.8 51.49,65.79 51.48,65.79 51.16,65.47 48.27,65.47 40.32,57.52 40.32,51.09 40.53,50.89 40.53,49.13 v3(41.91,47.74)
  BOTTOM w0.089: U7.AP47 61.4,65.81 v1(61.29,65.66)
M_A_DQ13: length 36.7
  TOP w0.089: U24.F2 43.68,48.17 v3(43.37,48.48)
  IN1 w0.089: 56.71,65.06 57.82,65.06 57.83,65.07 58.16,65.07 58.17,65.06 59.27,65.06 v1(59.87,65.66)
  IN1 w0.107: v3(43.37,48.48) 43.19,48.48 42.72,48.95 42.72,48.95 42.43,49.24 42.43,49.38 41.9,49.91 41.75,49.91 41.6,49.76 41.45,49.76 41.3,49.91 41.3,50.06 41.45,50.21 41.45,50.37 41.31,50.5 41.31,51.48 40.96,51.83 40.96,52.48 41.31,52.84 41.31,53.08 41.21,53.18 41.06,53.18 40.96,53.28 40.96,53.48 41.06,53.58 41.21,53.58 41.31,53.69 41.31,53.82 41.21,53.92 41.06,53.92 40.96,54.03 40.96,54.23 41.06,54.33 41.21,54.33 41.31,54.43 41.31,54.63 41.21,54.74 41.06,54.74 40.96,54.84 40.96,55.04 41.14,55.22 41.14,55.47 40.96,55.65 40.96,55.85 41.06,55.96 41.21,55.96 41.31,56.06 41.31,56.69 41.21,56.79 41.01,56.79 40.91,56.89 40.91,57.31 41.01,57.42 41.56,57.42 41.78,57.63 41.78,58.17 41.8,58.19 41.8,58.21 48.35,64.76 51.24,64.76 51.74,65.26 55.13,65.26 55.23,65.35 55.85,65.35 55.95,65.26 55.96,65.26 56.21,65.01 56.44,65.01 56.49,65.06 56.71,65.06
  BOTTOM w0.089: U7.AT50 v1(59.87,65.66)
M_A_DQ14: length 35.6
  TOP w0.094: v3(48.17,47.77) 48.16,47.77 U24.F7
  IN1 w0.089: 46.02,50.49 46.05,50.47 46.08,50.47 46.31,50.24 46.39,50.24 47.69,48.94 47.69,48.24 v3(48.17,47.77) ; 51.19,62.29 55.37,62.29 55.46,62.2 55.46,61.83 55.46,61.83 55.46,61.3 55.61,61.15 55.84,61.15 55.92,61.24 55.92,62.2 56.01,62.29 56.19,62.29 56.28,62.2 56.28,61.33 56.37,61.24 56.52,61.24 56.64,61.36 56.64,62.2 56.72,62.29 56.91,62.29 57,62.2 57,62.09 57.09,62 57.27,62 57.55,62.29 60.18,62.29 v1(60.58,62.69)
  IN1 w0.107: 51.19,62.29 51.12,62.22 49.11,62.22 43.93,57.04 43.93,52.71 44.57,52.07 44.57,51.86 45.08,51.35 45.19,51.35 45.36,51.19 45.36,50.92 45.51,50.76 45.68,50.76 45.95,50.49 46.02,50.49
  BOTTOM w0.089: U7.AY50 60.42,62.93 v1(60.58,62.69)
M_A_DQ15: length 38.7
  TOP w0.094: v3(47.29,46.06) 47.4,46.17 48.17,46.17 48.29,46.29 U24.H8
  IN1 w0.089: 44.2,50.15 44.42,49.93 44.43,49.93 45.49,48.86 46.25,48.86 46.55,48.56 46.55,47.56 46.81,47.3 46.81,46.53 v3(47.29,46.06) ; 57.65,63.77 58.68,63.77 59,64.09 61.6,64.09 v1(62,63.68)
  IN1 w0.107: 44.2,50.15 43.83,50.15 43.11,50.87 43.11,51.09 42.61,51.59 42.61,57.67 48.86,63.92 51.38,63.92 51.46,63.85 57.58,63.85 57.65,63.77
  BOTTOM w0.089: U7.AV45 v1(62,63.68)
M_A_DQ16: length 39.7
  IN2 w0.089: 59.02,66.59 63.92,66.59 v1(64.85,65.66)
  IN2 w0.107: v3(46.16,51.44) 46.16,51.67 46.05,51.78 45.84,51.78 45.73,51.68 45.73,51.42 45.61,51.3 45.39,51.3 44.77,51.92 44.77,54.93 47.49,57.65 51.4,57.65 51.51,57.75 51.51,57.98 51.61,58.08 51.81,58.08 51.91,57.98 51.91,57.75 52.01,57.65 52.22,57.65 52.32,57.75 52.32,57.98 52.42,58.08 52.62,58.08 52.73,57.98 52.73,57.75 52.83,57.65 53.03,57.65 53.13,57.75 53.13,57.98 53.23,58.08 53.44,58.08 53.54,57.98 53.54,57.75 53.64,57.65 53.84,57.65 53.94,57.75 53.94,57.98 54.05,58.08 54.25,58.08 54.35,57.98 54.35,57.75 54.45,57.65 54.6,57.65 55.28,58.33 55.28,58.36 55.29,58.37 55.29,58.72 55.08,58.93 55.08,59.22 55.56,59.71 55.56,60.29 55.44,60.42 55.44,60.95 55.56,61.07 55.56,63.26 58.17,65.87 58.3,65.87 59.02,66.59
  BOTTOM w0.089: U7.AT40 v1(64.85,65.66)
  BOTTOM w0.094: U31.C8 44.02,50.32 44.05,50.32 44.18,50.18 44.72,50.18 45.12,50.59 45.3,50.59 v3(46.16,51.44)
M_A_DQ17: length 40.1
  IN2 w0.089: 58.4,65.21 59.43,66.24 62.85,66.24 v1(63.43,65.66)
  IN2 w0.094: 58.4,65.21 58.4,64.49 58.14,64.23
  IN2 w0.107: v1(45.2,54.14) 45.57,54.52 45.72,54.52 45.91,54.32 45.91,54.18 45.74,54 45.74,53.86 45.88,53.72 46.02,53.72 46.2,53.89 46.34,53.89 46.57,53.67 46.71,53.67 46.85,53.81 46.85,53.96 46.67,54.14 46.67,54.28 47.14,54.75 47.14,54.9 47,55.04 46.85,55.04 46.38,54.57 46.17,54.57 46.06,54.68 46.06,54.84 46.3,55.07 46.3,55.28 46.4,55.38 46.6,55.38 46.72,55.5 47.12,55.5 47.21,55.59 47.21,55.93 47.38,56.09 47.38,56.15 47.49,56.26 47.49,56.64 47.94,57.09 50.27,57.09 50.37,56.99 50.37,56.28 50.47,56.17 50.67,56.17 50.78,56.28 50.78,56.99 50.88,57.09 51.16,57.09 51.58,56.68 51.58,56.53 51.78,56.33 51.78,56.1 51.88,56 52.09,56 52.19,56.1 52.19,56.43 52.27,56.5 52.52,56.5 52.6,56.43 52.6,56.05 52.67,55.97 52.93,55.97 53,56.05 53,56.38 53.1,56.48 53.31,56.48 53.41,56.38 53.41,56.05 53.48,55.97 53.74,55.97 53.81,56.05 53.81,56.4 53.89,56.48 54.17,56.48 54.22,56.42 54.22,56.1 54.32,56 54.53,56 54.63,56.1 54.63,56.33 54.73,56.43 54.88,56.43 55.26,56.81 55.26,56.94 56.12,57.8 56.12,58.07 56.12,60.53 56.05,60.6 56.05,60.76 56.12,60.84 56.12,61.3 56.12,62.5 57.85,64.23 58.14,64.23
  BOTTOM w0.089: U7.AP42 63.61,65.91 63.53,65.81 v1(63.43,65.66)
  BOTTOM w0.094: U31.A7 44.57,53.51 v1(45.2,54.14)
M_A_DQ18: length 33.7
  IN2 w0.089: v3(48.97,50.17) 49.35,49.79 49.91,49.79 ; 65.16,64.1 65.16,64.4 65.72,64.95 65.83,64.95 v1(66.54,65.67)
  IN2 w0.094: 65.16,59.73 65.16,64.1
  IN2 w0.107: 49.91,49.79 50.1,49.6 50.35,49.6 50.45,49.49 50.45,49.17 50.55,49.07 50.75,49.07 50.85,49.17 50.85,49.49 50.95,49.6 55.69,49.6 56.05,49.95 56.05,50.41 57.9,52.26 58.6,52.26 59.36,53.03 59.51,53.03 59.76,52.77 59.91,52.77 60.05,52.92 60.05,53.06 59.8,53.31 59.8,53.46 60.02,53.69 60.17,53.69 60.79,53.06 60.94,53.06 61.08,53.2 61.08,53.35 60.45,53.97 60.45,54.12 60.84,54.51 61,54.51 61.07,54.44 61.22,54.44 61.37,54.59 61.37,54.74 61.3,54.81 61.3,54.96 62.93,56.59 62.93,58.31 63.25,58.63 64.06,58.63 65.16,59.73
  BOTTOM w0.089: U7.AT38 66.43,65.67 v1(66.54,65.67)
  BOTTOM w0.094: v3(48.97,50.17) 48.76,50.37 48.76,50.37 U31.C2
M_A_DQ19: length 37.3
  IN2 w0.089: 58.78,66.78 64.05,66.78 64.78,66.06 65.16,66.06 v1(65.56,65.66)
  IN2 w0.107: v3(46.43,50.91) 46.43,50.91 45.38,50.91 44.49,51.8 44.49,55.16 47.27,57.93 50.87,57.93 51.63,58.68 51.63,58.71 52.04,59.12 54.57,59.12 55.28,59.84 55.29,59.84 55.29,60.19 55.16,60.32 55.16,61.28 55.29,61.42 55.29,61.75 55.23,61.81 55.23,63.36 58.03,66.16 58.15,66.16 58.78,66.78
  BOTTOM w0.089: U7.AP40 65.29,66.02 65.38,65.91 v1(65.56,65.66)
  BOTTOM w0.094: v3(46.43,50.91) 46.43,50.74 46.25,50.55 45.54,50.55 45.39,50.39 45.37,50.39 44.75,49.77 U31.D7
M_A_DQ20: length 40.8
  IN2 w0.089: 62.24,64.2 v1(62.71,64.67)
  IN2 w0.094: 59.46,63.41 59.46,63.85 59.7,64.09 59.86,64.09 59.97,64.2 62.24,64.2
  IN2 w0.107: v3(48.19,53.31) 48.44,53.56 48.77,53.56 48.83,53.61 49.14,53.61 49.2,53.56 49.59,53.56 49.7,53.46 49.7,53.36 49.89,53.16 49.89,53.02 49.7,52.82 49.7,52.59 49.8,52.49 51.25,52.49 51.35,52.39 51.35,52.22 51.45,52.12 52.59,52.12 52.72,51.99 52.72,51.84 52.59,51.71 51.45,51.71 51.35,51.61 51.35,51.35 51.57,51.13 52.29,51.13 52.96,50.45 54.71,50.45 54.83,50.58 54.83,50.79 54.73,50.89 53.99,50.89 53.89,50.99 53.89,51.95 53.99,52.05 54.89,52.05 55,52.16 55,52.31 54.83,52.48 54.83,52.62 54.97,52.77 55.12,52.77 55.29,52.59 55.43,52.59 55.58,52.74 55.58,52.88 55.4,53.05 55.4,53.2 55.55,53.34 55.69,53.34 55.86,53.17 56.01,53.17 56.18,53.34 56.18,53.49 56.02,53.65 56.02,53.79 56.17,53.93 56.31,53.93 56.47,53.77 56.61,53.77 56.76,53.92 56.76,54.06 56.6,54.22 56.6,54.36 56.74,54.51 56.89,54.51 57.04,54.35 57.19,54.35 57.33,54.49 57.33,54.67 57.42,54.77 57.76,54.77 58.54,55.54 58.54,55.78 58.64,55.88 59.14,55.88 59.28,56.01 59.28,56.16 59.14,56.29 58.18,56.29 58.05,56.42 58.05,56.56 58.18,56.69 58.89,56.69 58.99,56.8 58.99,57 58.89,57.1 58.64,57.1 58.54,57.2 58.54,57.33 58.43,57.43 58.08,57.43 57.98,57.53 57.98,57.74 58.08,57.84 58.43,57.84 58.54,57.94 58.54,62.48 59.46,63.41
  BOTTOM w0.089: U7.AT44 62.89,64.91 v1(62.71,64.67)
  BOTTOM w0.094: U31.A3 47.76,52.17 47.76,52.89 v3(48.19,53.31)
M_A_DQ21: length 38.7
  IN2 w0.089: 48.81,50.59 47.55,50.59 v3(47.27,50.87) ; v1(64.85,64.67) 64.85,63.87 64.26,63.29 63.64,63.29 63.34,62.99
  IN2 w0.107: 48.81,50.59 48.83,50.56 50.69,50.56 50.84,50.41 51.2,50.41 51.3,50.31 51.3,50.08 51.4,49.98 51.6,49.98 51.7,50.08 51.7,50.31 51.81,50.41 51.97,50.41 52.48,49.9 55.03,49.9 55.82,50.69 55.82,50.83 55.7,50.96 55.7,51.1 55.84,51.25 55.98,51.25 56.11,51.12 56.25,51.12 56.4,51.27 56.4,51.41 56.27,51.53 56.27,51.68 56.42,51.82 56.56,51.82 56.68,51.7 56.83,51.7 57.45,52.32 57.45,52.33 57.77,52.65 58.59,52.65 60.07,54.12 60.07,54.27 59.27,55.06 59.27,55.21 59.39,55.33 59.58,55.33 60.35,54.55 60.5,54.55 62.4,56.46 62.4,58.66 61.83,59.22 60.13,59.22 59.25,60.11 59.25,61.98 59.46,62.19 62.81,62.19 63.2,62.59 63.2,62.85 63.34,62.99
  BOTTOM w0.089: U7.AV41 v1(64.85,64.67) ; U31.C3 47.57,50.57 v3(47.27,50.87)
M_A_DQ22: length 36.1
  IN2 w0.089: 58.38,65.57 59.23,66.42 63.38,66.42 v1(64.14,65.66)
  IN2 w0.107: v3(45.2,54.8) 45.55,55.16 45.7,55.16 45.77,55.08 45.91,55.08 46.02,55.19 46.02,55.41 45.99,55.44 45.99,55.59 46.13,55.73 46.27,55.73 46.35,55.66 46.49,55.66 46.63,55.8 46.63,55.95 46.56,56.02 46.56,56.16 46.7,56.31 46.85,56.31 46.92,56.24 47.06,56.24 47.21,56.38 47.21,56.52 47.14,56.59 47.14,56.74 47.77,57.37 51.4,57.37 51.6,57.16 51.6,57.04 51.85,56.78 52.41,56.78 52.54,56.92 52.54,57.22 52.64,57.32 52.85,57.32 52.95,57.22 52.95,56.83 53.02,56.76 53.26,56.76 53.26,56.76 53.6,56.76 53.78,56.93 53.93,56.93 54.1,56.76 54.12,56.76 54.12,56.76 54.75,56.76 54.9,56.91 54.9,57.36 55,57.46 55.35,57.46 55.84,57.95 55.84,58.8 55.74,58.9 55.59,58.9 55.49,59 55.49,59.2 55.59,59.31 55.74,59.31 55.84,59.41 55.84,60.41 55.77,60.49 55.77,60.88 55.84,60.96 55.84,61.19 55.84,63.11 56.13,63.4 56.28,63.4 56.38,63.3 56.52,63.3 56.66,63.45 56.66,63.59 56.57,63.69 56.57,63.83 56.71,63.97 56.85,63.97 56.95,63.88 57.09,63.88 57.24,64.02 57.24,64.16 57.14,64.26 57.14,64.41 58.31,65.57 58.38,65.57
  BOTTOM w0.089: v1(64.14,65.66) 64.25,65.81 64.32,65.91 U7.AP41
  BOTTOM w0.094: U31.B8 44.13,51.73 44.13,53.74 v3(45.2,54.8)
M_A_DQ23: length 40.4
  IN2 w0.089: v1(63.43,63.68) 62.93,63.18 59.71,63.18
  IN2 w0.107: v3(48.98,53.23) 48.58,52.82 48.58,52.23 48.68,52.13 48.81,52.13 49.12,52.13 49.35,51.9 49.35,51.72 49.71,51.36 49.96,51.36 50.47,50.85 51.92,50.85 52.59,50.18 54.83,50.18 55.39,50.74 55.39,51.07 55.28,51.17 54.42,51.17 54.32,51.27 54.32,51.48 54.42,51.58 55.28,51.58 55.39,51.68 55.39,52.16 56.02,52.8 56.47,52.8 56.58,52.9 56.58,53.03 56.68,53.13 57.68,53.13 57.79,53.24 57.79,53.48 57.9,53.58 58.1,53.58 58.2,53.48 58.2,53.1 58.3,53 58.51,53 58.95,53.44 58.95,53.63 58.52,54.06 58.52,54.2 58.66,54.35 58.81,54.35 59.24,53.92 59.38,53.92 59.52,54.06 59.52,54.21 58.76,54.96 58.76,55.11 59.27,55.61 61.04,55.61 61.43,56 61.43,57 62.12,57.7 62.12,58.4 61.86,58.66 60.06,58.66 59.81,58.92 59.43,58.92 59.17,59.18 59.17,59.56 58.84,59.88 58.84,62.32 59.71,63.18
  BOTTOM w0.089: U7.AV42 63.49,63.77 v1(63.43,63.68)
  BOTTOM w0.094: U31.A2 48.57,52.17 48.57,52.81 v3(48.98,53.23)
M_A_DQ24: length 22
  TOP w0.089: v3(47.38,50.18) 47.38,50.15 U24.D7
  IN1 w0.089: 49.61,50.58 49.51,50.58 49.38,50.46 49.38,49.83 49.3,49.74 48.82,49.74 48.64,49.92 48.45,49.92 48.3,49.77 47.93,49.77 47.79,49.91 47.79,50.03 47.64,50.18 v3(47.38,50.18)
  IN1 w0.107: 49.61,50.58 49.92,50.58 50.15,50.81 50.15,50.81 50.23,50.89 50.23,51.05 50.38,51.2 50.38,51.46 50.23,51.61 50.23,51.88 50.46,52.11 50.46,52.64 50.56,52.74 50.66,52.74 50.76,52.84 50.76,53.05 50.66,53.15 50.56,53.15 50.46,53.25 50.46,54.8 50.66,55.01 50.92,55.01 51.08,55.17 51.08,55.42 51.22,55.56 51.42,55.56 51.89,56.03 51.89,56.23 51.99,56.33 52.26,56.33 52.69,56.76 52.69,57.09 53.12,57.52 53.12,57.59 53.23,57.7 53.48,57.7 53.79,57.39 53.93,57.39 54.47,57.93 54.47,58.13 v1(54.88,58.54)
  BOTTOM w0.094: U7.BD52 59.18,61.08 58.92,61.34 58.92,61.35 58.73,61.54 57.95,61.54 57.84,61.43 57.84,61.43 57.6,61.2 57.6,61.19 57.57,61.16 57.57,60.82 55.28,58.54 v1(54.88,58.54)
