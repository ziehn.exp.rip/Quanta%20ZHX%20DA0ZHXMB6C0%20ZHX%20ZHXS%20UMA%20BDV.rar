# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ0: length 31.7
  IN2 w0.094: v1(90.35,66.87) 90.62,66.59 91.4,66.59
  IN2 w0.107: v3(101.8,50.17) 102.21,50.57 102.21,51.93 102.29,52.01 102.29,52.48 102.29,52.48 102.29,52.8 102.29,52.8 102.29,57.17 93.94,65.52 92.47,65.52 91.4,66.59
  BOTTOM w0.089: U7.AK3 83.41,68.07 83.71,68.37 83.95,68.37 84.05,68.27 84.51,68.27 84.66,68.12 86.06,68.12
  BOTTOM w0.094: v1(90.35,66.87) 89.94,67.27 89.64,67.27 89.38,67.53 88.6,67.53 88.24,67.88 86.3,67.88 86.06,68.12 ; U33.C2 v3(101.8,50.17)
M_B_DQ1: length 29.9
  IN2 w0.094: 91.18,66.18 88.96,66.18 v1(88.28,66.87)
  IN2 w0.107: v3(101.08,53.41) 101.26,53.58 101.26,57.29 97.69,60.86 96.73,60.86 96.44,60.57 96.26,60.57 96.11,60.72 96.11,60.89 96.47,61.24 96.47,61.39 96.34,61.51 96.16,61.51 95.81,61.16 95.62,61.16 94.51,62.27 94.51,63.55 93.03,65.02 92.72,65.02 92.66,64.97 92.39,64.97 91.18,66.18
  BOTTOM w0.089: U7.AL3 83.65,67.76 83.94,67.76 84.05,67.87 84.38,67.87 84.55,67.7 85.37,67.7
  BOTTOM w0.094: v1(88.28,66.87) 87.85,67.3 86.12,67.3 85.9,67.52 85.55,67.52 85.37,67.7 ; v3(101.08,53.41) 100.6,52.92 100.6,52.17 U33.A3
M_B_DQ2: length 31
  IN2 w0.107: v3(98.74,50.67) 98.48,50.67 97.6,51.55 97.6,52.04 97.03,52.61 97.03,53.12 97.19,53.29 97.19,54.07 96.35,54.91 95.39,54.91 94.39,55.91 94.39,57.1 93.86,57.63 93.29,57.63 92.39,58.52 91.26,58.52 91.13,58.65 91.13,58.97 91.26,59.1 92.15,59.1 92.48,59.42 92.48,59.82 92.25,60.04 89.03,60.04 88.55,60.52 88.55,62.49 88.84,62.78 v1(89.19,62.78)
  BOTTOM w0.089: 85,65.07 84.07,65.07 83.98,65.16 U7.AT2
  BOTTOM w0.094: v3(98.74,50.67) 98.25,50.18 96.98,50.18 U33.C8 ; v1(89.19,62.78) 88.15,63.82 87.31,63.82 86.81,64.33 86.42,64.33 86.35,64.39 85.78,64.39 85.77,64.4 85.68,64.4 85,65.07
M_B_DQ3: length 33.2
  IN2 w0.107: v1(89.9,62.78) 89.9,62.38 90.12,62.16 91.76,62.16 91.89,62.04 91.89,61.8 91.73,61.65 89,61.65 88.83,61.48 88.83,60.66 89.16,60.33 89.32,60.33 89.43,60.43 89.43,60.68 89.53,60.78 89.73,60.78 89.83,60.68 89.83,60.43 89.93,60.33 90.14,60.33 90.24,60.43 90.24,60.68 90.34,60.78 90.54,60.78 90.64,60.68 90.64,60.43 90.75,60.33 90.95,60.33 91.05,60.43 91.05,60.68 91.15,60.78 91.36,60.78 91.46,60.68 91.46,60.43 91.56,60.33 91.76,60.33 91.86,60.43 91.86,60.68 91.97,60.78 92.17,60.78 92.27,60.68 92.27,60.43 92.37,60.33 92.6,60.33 92.85,60.08 92.85,58.46 93.19,58.13 94.04,58.13 94.19,58.28 94.65,58.28 94.91,58.02 94.91,57.57 94.67,57.33 94.67,56.05 95.53,55.19 96.53,55.19 97.64,54.07 97.64,53.7 97.72,53.63 97.72,53.03 v3(97.44,52.75)
  BOTTOM w0.089: U7.AR3 83.66,65.45 83.95,65.45 84.06,65.34 85.22,65.34
  BOTTOM w0.094: 85.22,65.34 85.89,64.67 86.94,64.67 87.44,64.17 88.51,64.17 v1(89.9,62.78) ; v3(97.44,52.75) 97.44,52.21 U33.A7
M_B_DQ4: length 32.2
  IN2 w0.094: v3(100.24,50.97) 100.06,50.79 99.55,50.79 98.97,51.37 98.97,51.82 99.3,52.15
  IN2 w0.107: v1(87.57,66.87) 87.57,65.48 87.48,65.39 87.48,64.55 88.51,63.51 92.4,63.51 93.2,62.71 93.2,61.12 93.87,60.45 93.87,59.62 94.37,59.12 97.17,59.12 98.6,57.69 98.6,56.87 98.38,56.65 97.83,56.65 97.71,56.53 97.71,56.23 97.81,56.13 98.61,56.13 99.3,55.44 99.3,52.15
  BOTTOM w0.089: 85.25,67.5 84.3,67.5 U7.AL1
  BOTTOM w0.094: v1(87.57,66.87) 87.39,66.69 87.24,66.69 86.98,66.43 86.63,66.43 85.82,67.24 85.51,67.24 85.25,67.5 ; U33.C3 100.6,50.61 v3(100.24,50.97)
M_B_DQ5: length 29.7
  IN2 w0.094: 91.26,66.37 90.2,66.37 v1(89.7,66.87)
  IN2 w0.107: 91.26,66.37 92.4,65.23 93.72,65.23 95.37,63.59 95.37,63.32 95.09,63.05 95.09,62.91 95.24,62.76 95.38,62.76 95.65,63.03 95.8,63.03 96.02,62.81 96.02,62.66 95.7,62.34 95.7,62.19 95.84,62.05 95.98,62.05 96.31,62.38 96.66,62.38 101.68,57.36 v3(101.68,53.23)
  BOTTOM w0.089: U7.AK2 84.45,68.07 84.61,67.91 85.57,67.91
  BOTTOM w0.094: v1(89.7,66.87) 89.3,67.27 88.53,67.27 88.22,67.58 86.22,67.58 86.01,67.79 85.69,67.79 85.57,67.91 ; v3(101.68,53.23) 101.4,52.95 101.4,52.17 U33.A2
M_B_DQ6: length 32.7
  IN2 w0.107: v1(91.33,62.78) 91.74,63.19 92.31,63.19 92.88,62.63 92.88,60.96 93.57,60.27 93.57,59.06 93.79,58.84 96.83,58.84 96.94,58.73 96.94,58.45 96.81,58.32 95.64,58.32 95.48,58.15 95.48,57.91 95.62,57.77 97.09,57.77 97.36,57.5 97.36,55.66 97.56,55.46 98.52,55.46 98.78,55.21 98.78,52.9 99.02,52.65 99.02,52.27 98.69,51.93 98.69,51.26 99.12,50.82 99.12,50.5 99.25,50.37 v3(99.25,50.3)
  BOTTOM w0.089: U7.AR1 85.32,65.64
  BOTTOM w0.094: 85.32,65.64 86.01,64.95 87.06,64.95 87.56,64.45 88.78,64.45 89.95,63.28 90.83,63.28 v1(91.33,62.78) ; U33.D7 98.72,49.77 v3(99.25,50.3)
M_B_DQ7: length 34.9
  IN2 w0.094: v3(98.03,52.12) 98.03,52.54 98.26,52.77 98.27,52.77 98.49,52.99 98.49,53.31 98.49,53.32
  IN2 w0.107: v1(92.04,62.78) 92.52,62.29 92.52,60.93 93.29,60.16 93.29,58.78 93.51,58.56 94.77,58.56 95.19,58.14 95.19,57.59 95.3,57.49 96.98,57.49 97.08,57.39 97.08,57.18 96.98,57.08 95.3,57.08 95.19,56.98 95.19,56.78 95.3,56.68 96.98,56.68 97.08,56.57 97.08,56.37 96.98,56.27 95.37,56.27 95.24,56.14 95.24,55.98 95.41,55.8 96.84,55.8 96.98,55.66 96.98,55.27 97.12,55.14 98.31,55.14 98.49,54.96 98.49,53.32
  BOTTOM w0.089: 85.43,65.93 84.05,65.93 83.95,65.83 83.71,65.83 83.53,66 83.41,66.13 U7.AP3
  BOTTOM w0.094: U33.B8 96.6,51.37 97.04,51.81 97.72,51.81 v3(98.03,52.12) ; 85.43,65.93 86.12,65.23 87.17,65.23 87.64,64.76 88.97,64.76 90.12,63.61 90.95,63.61 91.34,63.21 91.5,63.21 91.56,63.16 91.66,63.16 v1(92.04,62.78)
M_B_DQ8: length 49.9
  IN1 w0.089: 92.62,65.65 92.16,65.65 91.61,66.21 85.21,66.21 85.04,66.03 84.16,66.03 84.04,66.16 82.72,66.16 v1(82.22,65.66)
  IN1 w0.107: 92.62,65.65 94.57,65.65 101.79,58.43 102.02,58.43 102.02,58.43 103.41,57.04 103.52,57.04 106.47,54.1 106.47,48.33 105.4,47.27 105.1,47.27 104.93,47.09 104.47,46.63 104.15,46.32 103.04,45.2 102.69,45.2 102.2,44.71 99.77,44.71 99.76,44.72 99.7,44.72 98.92,45.51 98.78,45.51 98.78,45.51 98.6,45.51 97.39,46.72 97.39,48.13 v3(96.99,48.53)
  BOTTOM w0.089: U7.AP6 81.9,66.08 v1(82.22,65.66)
  BOTTOM w0.094: U33.F7 97.36,48.17 v3(96.99,48.53)
M_B_DQ9: length 51.6
  IN1 w0.089: 102.81,45.76 101.19,45.76 101.18,45.76 100.87,45.76 100.62,46.01 100.62,46.13 v3(100.07,46.68) ; 92.51,65.11 91.91,65.11 91.25,65.77 87.59,65.77 87.01,65.2 87.01,64.58 86.93,64.49 86.75,64.49 86.66,64.58 86.66,65.17 86.57,65.26 86.39,65.26 86.3,65.17 86.3,64.58 86.21,64.49 86.04,64.49 85.95,64.58 85.95,65.17 85.86,65.26 85.68,65.26 85.57,65.16 85.57,64.63 85.47,64.53 85.3,64.53 85.21,64.62 85.21,65.46 85.07,65.61 84.89,65.61 84.8,65.52 84.8,65.35 84.71,65.26 84.54,65.26 84.45,65.35 84.45,65.52 84.36,65.61 84.18,65.61 84.09,65.52 84.09,65.35 84,65.26 83.83,65.26 83.74,65.35 83.74,65.68 83.64,65.78 83.47,65.78 83.38,65.69 83.38,65.35 83.29,65.26 81.66,65.26 81.51,65.11 v1(81.51,64.67)
  IN1 w0.107: 92.51,65.11 94.17,65.11 101.4,57.88 101.78,57.88 102.17,57.49 102.17,57.49 103.18,56.48 103.29,56.48 105.91,53.86 105.91,51.33 105.8,51.23 105.58,51.23 105.47,51.13 105.47,50.92 105.58,50.82 105.8,50.82 105.91,50.72 105.91,50.52 105.8,50.41 105.58,50.41 105.47,50.31 105.47,50.11 105.58,50.01 105.8,50.01 105.91,49.91 105.91,49.7 105.8,49.6 105.58,49.6 105.47,49.5 105.47,49.3 105.58,49.19 105.8,49.19 105.91,49.09 105.91,48.57 105.22,47.88 104.93,47.88 104.37,47.32 104.37,47.32 102.81,45.76
  BOTTOM w0.089: v1(81.51,64.67) U7.AT7
  BOTTOM w0.094: U33.H3 100.6,46.57 100.19,46.57 v3(100.07,46.68)
M_B_DQ10: length 45.3
  IN1 w0.089: v1(81.51,62.69) 81.51,62.96 81.64,63.09 83.19,63.09 83.58,62.7 84.01,62.7 84.09,62.62 84.09,62.19 84.63,61.65 85.87,61.65 85.95,61.57 85.95,61.19 86.16,60.99 86.32,60.99 86.45,61.12 86.62,61.12 86.71,61.03 86.71,60.43 86.8,60.34 86.94,60.34 87.03,60.43 87.03,61.06 87.12,61.14 87.25,61.14 87.34,61.06 87.34,59.36 87.42,59.29 87.47,59.29 87.93,58.82 ; 102.18,49.57 102.18,49.12 102.05,48.99 101.88,48.99 101.8,48.9 v3(101.8,48.6)
  IN1 w0.107: 87.93,58.82 88.19,58.82 88.42,59.05 88.42,59.43 87.7,60.15 87.7,61.08 87.84,61.21 88.24,61.21 88.44,61.41 88.44,61.56 88.31,61.68 88.31,61.83 88.58,62.09 88.58,62.24 88.39,62.42 88.39,63.16 88.14,63.42 88.14,63.54 88.29,63.69 88.41,63.69 88.68,63.43 92.26,63.43 92.47,63.23 93.32,63.23 97.65,58.9 97.76,58.9 102.06,54.6 102.46,54.6 103.53,53.53 103.53,49.74 103.26,49.48 103.07,49.48 102.79,49.76 102.36,49.76 102.18,49.57
  BOTTOM w0.089: U7.AY6 81.69,62.93 v1(81.51,62.69)
  BOTTOM w0.094: v3(101.8,48.6) 101.4,48.2 U33.F2
M_B_DQ11: length 45.6
  IN1 w0.089: 88.91,63.95 88.81,64.05 88.81,64.31 88.71,64.41 88.17,64.41 87.64,63.88 87.64,63.16 87.68,63.12 87.68,62.99 87.55,62.86 87.36,62.86 87.28,62.78 87.28,61.78 87.19,61.69 87.06,61.69 86.98,61.78 86.98,62.77 86.89,62.86 86.75,62.86 86.67,62.78 86.67,61.67 86.59,61.59 86.45,61.59 86.37,61.67 86.37,62.69 86.29,62.76 86.14,62.76 86.06,62.69 86.06,62.14 85.99,62.07 85.85,62.07 85.76,62.16 85.76,62.69 85.68,62.76 85.53,62.76 85.45,62.69 85.45,62.18 85.37,62.1 85.23,62.1 85.15,62.18 85.15,62.61 85.07,62.69 84.92,62.69 84.84,62.61 84.84,62.31 84.76,62.22 84.62,62.22 84.54,62.3 84.54,62.99 84.47,63.05 83.85,63.05 83.22,63.68 v1(82.93,63.68) ; 102.81,48.21 102.47,48.21 102.05,47.79 101.84,47.79 101.79,47.84
  IN1 w0.107: 102.81,48.21 102.96,48.37 102.96,48.37 104.11,49.52 104.11,53.73 103.01,54.84 102.68,55.16 102.68,55.16 102.66,55.17 102.27,55.17 102.25,55.19 102.25,55.19 100.87,56.58 100.86,56.58 98.87,58.57 97.99,59.45 97.89,59.45 97.35,59.99 97.35,59.99 93.53,63.82 92.53,63.82 92.42,63.93 91.45,63.93 91.35,64.03 91.35,64.29 91.22,64.42 90.99,64.42 90.89,64.32 90.89,64.03 90.78,63.93 90.59,63.93 90.49,64.03 90.49,64.28 90.38,64.38 90.18,64.38 90.08,64.28 90.08,64.03 89.97,63.93 89.77,63.93 89.67,64.03 89.67,64.26 89.57,64.36 89.33,64.36 89.25,64.27 89.25,64.05 89.15,63.95 88.91,63.95 ; v3(101.79,47.84) 101.79,47.84
  BOTTOM w0.089: v1(82.93,63.68) 82.57,64.13 U7.AV4
  BOTTOM w0.094: U33.G2 101.4,47.44 v3(101.79,47.84)
M_B_DQ12: length 51
  IN1 w0.089: 99.92,44.44 99.67,44.44 99.65,44.46 99.34,44.46 99.21,44.34 98.89,44.34 98.79,44.44 98.26,44.44 97.38,45.32 97.38,45.71 97.09,46 96.7,46 96.49,46.21 v3(96.2,46.21) ; v1(81.51,65.66) 82.18,66.33 84.11,66.33 84.23,66.21 84.97,66.21 85.14,66.38 91.8,66.38 92.26,65.93 92.48,65.93 92.48,65.92 92.62,65.92
  IN1 w0.107: 99.92,44.44 102.32,44.44 102.8,44.92 103.16,44.92 105.21,46.98 105.51,46.98 106.74,48.22 106.74,54.21 103.64,57.32 103.53,57.32 103,57.84 102.13,58.71 102.09,58.71 101.9,58.71 98.58,62.03 98.58,62.03 98.34,62.27 98.34,62.28 94.71,65.91 94.7,65.91 94.68,65.92 92.62,65.92
  BOTTOM w0.089: U7.AP7 81.19,66.08 v1(81.51,65.66)
  BOTTOM w0.094: U33.H8 96.56,46.57 v3(96.2,46.21)
M_B_DQ13: length 49.5
  IN1 w0.089: v1(82.93,65.66) 83.25,65.98 83.84,65.98 84.01,65.81 85.14,65.81 85.27,65.94 85.47,65.94 85.54,65.86 85.54,65.61 85.63,65.53 85.77,65.53 85.85,65.61 85.85,65.86 85.92,65.94 86.08,65.94 86.15,65.86 86.15,65.68 86.24,65.59 86.38,65.59 86.46,65.67 86.46,65.86 86.53,65.94 86.69,65.94 86.76,65.86 86.76,65.75 86.84,65.67 86.99,65.67 87.07,65.75 87.07,65.92 87.18,66.03 91.45,66.03 92.1,65.38 92.62,65.38
  IN1 w0.107: v3(98.29,47.28) 98.59,47.28 98.79,47.08 98.79,46.83 98.63,46.67 98.51,46.67 98.4,46.57 98.4,46.11 98.6,45.91 99.11,45.91 99.33,46.13 100.02,46.13 100.5,45.65 100.5,45.28 100.78,44.99 102.08,44.99 102.57,45.48 102.92,45.48 104.04,46.6 104.47,47.03 104.65,47.2 104.65,47.21 105.01,47.57 105.31,47.57 106.19,48.45 106.19,48.57 106.19,53.98 103.41,56.76 103.3,56.76 102.45,57.61 102.45,57.61 101.9,58.16 101.61,58.16 94.38,65.38 92.62,65.38
  BOTTOM w0.089: U7.AT4 82.57,65.2 v1(82.93,65.66)
  BOTTOM w0.094: v3(98.29,47.28) 98.29,46.93 98.16,46.8 98.16,46.8 97.93,46.58 97.93,46.58 97.92,46.57 U33.H7
M_B_DQ14: length 48
  IN1 w0.089: 101.41,49.14 101.26,48.98 100.84,48.98 100.59,49.23 99.97,49.23 99.92,49.28 99.85,49.28 99.8,49.33 99.73,49.33 99.73,49.33 99.23,49.33 98.85,48.95 97.73,48.95 97.69,48.99 96.62,48.99 v3(96.2,48.57) ; v1(82.22,62.69) 82.62,62.28 83.72,62.28 84.55,61.46 85.31,61.46 87.07,59.69 87.07,59.25 87.31,59.02 87.31,59.02
  IN1 w0.107: 87.31,59.02 88.22,58.12 88.59,58.12 89.1,58.63 89.1,59.05 88.78,59.37 88.78,59.51 88.06,60.23 88.06,60.76 88.23,60.94 88.47,60.94 88.59,61.06 88.6,61.06 88.74,61.2 88.74,61.41 89,61.67 90.09,61.67 90.24,61.82 90.24,62.25 90.14,62.36 88.92,62.36 88.75,62.53 88.75,62.96 88.98,63.19 92.21,63.19 92.44,62.95 93.13,62.95 97.47,58.61 97.66,58.61 101.94,54.32 102.11,54.32 102.11,54.32 102.34,54.32 103.21,53.45 103.21,51.02 102.74,50.55 102.44,50.55 102.2,50.31 102.2,49.99 101.96,49.75 101.64,49.75 101.41,49.53 101.41,49.49 101.41,49.49 101.41,49.14
  BOTTOM w0.089: U7.AY4 82.38,62.93 v1(82.22,62.69) ; U33.F8 96.6,48.17
  BOTTOM w0.094: 96.6,48.17 v3(96.2,48.57)
M_B_DQ15: length 50.2
  IN1 w0.089: v3(99.69,48.93) 100.44,48.93 100.62,48.75 100.62,48.41 100.81,48.22 101.99,48.22 102.22,48.45 102.22,48.75 102.44,48.97 103.15,48.97 ; v1(80.8,63.68) 81.09,63.97 81.09,64.11 81,64.2 77.79,64.2 77.69,64.1 77.69,63.34 77.79,63.24 79.93,63.24 80.01,63.16 80.43,63.16 80.5,63.09 81.05,63.09 81.23,63.28 83.29,63.28 83.69,62.87 84.13,62.87 84.27,62.74 84.27,62.3 84.69,61.87 86.06,61.87 86.16,61.77 86.16,61.53 86.28,61.41 87.55,61.41 88.12,61.97 88.12,63.01 87.85,63.27 87.85,63.68 88.29,64.13 88.47,64.13 88.58,64.02 88.58,63.85 88.76,63.67
  IN1 w0.107: 103.15,48.97 103.83,49.65 103.83,53.62 102.57,54.88 102.55,54.88 102.17,54.88 97.87,59.18 97.77,59.18 97.69,59.27 97.68,59.27 93.44,63.51 92.52,63.51 92.35,63.67 88.76,63.67
  BOTTOM w0.089: v1(80.8,63.68) 80.47,64.14 U7.AV9
  BOTTOM w0.094: U33.E3 100.56,48.93 v3(99.69,48.93)
M_B_DQ16: length 38.2
  TOP w0.094: U27.F7 100.67,48.17 v3(101,47.84)
  IN2 w0.089: 84.52,65.5 84.29,65.73 84.01,65.73 83.38,66.36 83.38,66.36 83.31,66.43 78.72,66.43 v1(77.95,65.66) ; 96.91,50.54 97.78,50.54 98.95,49.37 99.92,49.37 100.51,48.77 100.51,48.46 101.01,47.97 101.01,47.84 v3(101,47.84)
  IN2 w0.107: 84.52,65.5 85.1,65.5 85.58,65.02 85.58,65.01 87.88,62.71 87.88,59.91 91.05,56.74 91.29,56.74 91.65,57.1 91.8,57.1 91.96,56.94 91.96,56.79 91.56,56.39 91.56,56.24 91.7,56.1 91.84,56.1 92.35,56.61 92.5,56.61 92.64,56.47 92.64,56.32 92.11,55.79 92.11,55.65 92.23,55.53 92.42,55.53 92.67,55.78 92.98,55.78 93.35,55.41 93.69,55.41 96.16,52.95 96.16,52.35 96.64,51.87 96.64,51.13 96.63,51.13 96.63,50.81 96.86,50.58 96.86,50.58 96.91,50.54
  BOTTOM w0.089: U7.AT14 v1(77.95,65.66)
M_B_DQ17: length 38.1
  TOP w0.094: v3(101.03,46.15) 100.61,46.57 U27.H7
  IN2 w0.089: v1(79.37,65.66) 79.37,65.95 79.5,66.08 83.1,66.08 83.52,65.66 83.52,65.59 83.68,65.42 ; v3(101.03,46.15) 100.97,46.15 100.95,46.17 100.6,46.17 100.45,46.32 100.45,46.95 100.31,47.1 100.31,48.01 100.02,48.29 99.53,48.29 99.15,48.68 99.08,48.68 97.6,50.15 96.74,50.15 96.24,50.64 95.84,50.64 95.62,50.86 95.62,51.09
  IN2 w0.107: 95.62,51.09 95.62,51.31 95.53,51.41 95.53,52.76 94.64,53.65 94.48,53.65 93.95,53.12 93.8,53.12 93.64,53.28 93.64,53.43 93.99,53.77 93.99,53.93 93.87,54.05 93.68,54.05 93.26,53.62 93.11,53.62 92.97,53.76 92.97,53.91 93.37,54.31 93.37,54.46 93.27,54.57 93.03,54.57 92.79,54.33 92.6,54.33 87.32,59.61 87.32,62.44 85.54,64.22 84.63,64.22 84.38,64.46 84.38,64.72 83.68,65.42
  BOTTOM w0.089: U7.AP12 79.06,66.08 v1(79.37,65.66)
M_B_DQ18: length 32.1
  TOP w0.094: U27.G2 96.25,47.02 95.51,47.02 94.99,47.54 94.85,47.54 94.69,47.69 v3(94.69,48.11)
  IN2 w0.089: 84.21,57.47 84.21,59.5 83.73,59.98 83.73,61.66 83.24,62.16 79.83,62.16 79.27,62.72 79.05,62.72 78.62,63.15 78.44,63.15 77.64,63.96 77.64,64.42 77.55,64.5 77.55,64.63 v1(77.23,64.95)
  IN2 w0.107: v3(94.69,48.11) 93.23,48.11 93.2,48.15 92.64,48.15 91.79,49 89.59,49 84.21,54.37 84.21,57.47
  BOTTOM w0.089: U7.AT16 v1(77.23,64.95)
M_B_DQ19: length 35.8
  TOP w0.094: v3(101,48.6) 101.4,48.21 U27.F8
  IN2 w0.089: v1(77.04,65.76) 77.43,66.16 78.16,66.16 78.62,66.61 83.43,66.61 84.11,65.94 ; 98.06,50.54 98.99,49.6 100,49.6 101,48.61 v3(101,48.6)
  IN2 w0.107: 84.11,65.94 85.05,65.94 85.28,65.71 85.43,65.71 85.59,65.87 85.74,65.87 85.89,65.72 85.89,65.57 85.73,65.41 85.73,65.26 88.16,62.83 88.16,60.08 90.85,57.39 92.11,57.39 96.45,53.05 96.45,52.52 97,51.96 97,51.59 98.06,50.54
  BOTTOM w0.089: v1(77.04,65.76) U7.AP14
M_B_DQ20: length 39.1
  TOP w0.094: U27.E3 97.2,49.16 97.15,49.22 97.15,49.26 96.93,49.47 96.93,49.91 96.6,50.24 96.46,50.24 96.27,50.43 96.27,50.57 95.92,50.92 95.49,50.92 95.06,51.35 v3(94.45,51.35)
  IN2 w0.089: v1(80.09,64.67) 80.49,65.07 83.14,65.07 83.3,64.91
  IN2 w0.107: 83.3,64.91 83.88,64.33 83.88,63.91 86.75,61.04 86.75,59.31 87.7,58.36 87.7,58.22 86.99,57.51 86.99,57.36 87.13,57.23 87.29,57.23 87.99,57.93 88.13,57.93 88.28,57.79 88.28,57.64 87.59,56.96 87.59,56.78 87.7,56.67 87.88,56.67 87.94,56.73 88.09,56.73 88.32,56.49 88.47,56.49 88.63,56.64 88.63,56.79 88.39,57.03 88.39,57.18 88.57,57.36 88.71,57.36 89.65,56.41 89.65,56.27 88.85,55.46 88.85,55.32 88.99,55.17 89.13,55.17 89.94,55.98 90.09,55.98 90.23,55.84 90.23,55.69 89.6,55.07 89.6,54.92 89.74,54.79 89.9,54.79 90.52,55.41 90.66,55.41 90.81,55.26 90.81,55.12 90.34,54.65 90.34,54.49 90.47,54.35 90.62,54.35 91.09,54.83 91.24,54.83 91.4,54.66 91.4,54.51 90.9,54 90.9,53.86 91.03,53.73 91.21,53.73 91.5,54.02 91.64,54.02 93.35,52.31 93.9,52.31 94,52.21 94,51.8 v3(94.45,51.35)
  BOTTOM w0.089: U7.AT10 v1(80.09,64.67)
M_B_DQ21: length 37.2
  TOP w0.094: U27.F2 96.2,47.77 v3(96.2,47.77)
  IN2 w0.089: 84.84,59.4 84.09,60.15 84.09,62.1 83.1,63.09 79.05,63.09 78.8,63.34 78.51,63.34 77.95,63.9 v1(77.95,64.67) ; v3(96.2,47.77) 95.84,48.13 95.26,48.13 ; 85.3,57.47 85.3,58.94 85.17,59.07
  IN2 w0.094: 95.26,48.13 94.9,48.49 94.57,48.49
  IN2 w0.107: 85.3,57.47 85.3,56.98 85.18,56.86 85.18,56.73 85.08,56.62 84.6,56.62 84.49,56.51 84.49,56.3 84.6,56.19 85.08,56.19 85.18,56.09 85.18,54.91 85.08,54.8 84.73,54.8 84.63,54.69 84.63,54.48 84.73,54.37 85.08,54.37 85.18,54.27 85.18,53.83 88.5,50.51 88.75,50.51 89.38,51.14 89.56,51.14 89.69,51.02 89.69,50.88 89.03,50.22 89.03,50.07 89.17,49.93 89.32,49.93 90.01,50.63 90.16,50.63 90.3,50.49 90.3,50.34 89.67,49.71 89.67,49.54 89.79,49.42 91.86,49.42 92.79,48.49 94.57,48.49 ; 85.17,59.07 84.84,59.4
  BOTTOM w0.089: U7.AV13 78,64.61
  BOTTOM w0.094: 78,64.61 v1(77.95,64.67)
M_B_DQ22: length 36.2
  TOP w0.094: v3(101.79,46.14) 101.4,46.54 U27.H8
  IN2 w0.089: 96.05,51.09 96.81,50.33 97.71,50.33 98.99,49.04 99.04,49.04 99.53,48.56 100.01,48.56 100.48,48.08 100.48,47.32 100.62,47.18 100.62,46.76 100.86,46.52 101.19,46.52 101.44,46.52 101.79,46.17 v3(101.79,46.14) ; v1(78.66,65.66) 79.26,66.25 83.23,66.25 83.3,66.18 83.31,66.18 83.94,65.55
  IN2 w0.107: 83.94,65.55 84.32,65.17 85.09,65.17 85.38,64.88 85.38,64.81 87.6,62.6 87.6,59.72 92.48,54.84 93.83,54.84 94.48,54.19 95.81,52.86 95.81,51.59 95.97,51.43 95.97,51.17 96.05,51.09
  BOTTOM w0.089: U7.AP13 78.35,66.08 78.55,65.82 v1(78.66,65.66)
M_B_DQ23: length 38.3
  TOP w0.094: U27.H3 97.78,46.95 v3(97.78,46.95)
  IN2 w0.089: v1(79.37,63.68) 79.37,63.37 79.46,63.28 79.92,63.28 79.92,63.28 83.1,63.28 83.1,63.28 83.25,63.28 ; 94.73,48.79 95.05,48.79 95.24,48.98 96.47,48.98 96.59,48.85 96.59,48.33 96.78,48.15 97.19,48.15 97.78,47.55 v3(97.78,46.95)
  IN2 w0.107: 83.25,63.28 84.45,62.07 84.45,61.96 85.25,61.16 85.25,60.36 85.25,60.35 85.25,60.02 85.22,59.98 85.22,59.53 85.73,59.02 85.73,55.65 86.32,55.07 86.32,54.74 85.7,54.13 85.7,53.76 86.83,52.63 86.97,52.63 87.49,53.15 87.63,53.15 87.78,53.01 87.78,52.86 87.26,52.34 87.26,52.2 87.88,51.58 88.12,51.58 88.24,51.69 88.38,51.69 88.74,51.33 88.9,51.33 89.04,51.47 89.04,51.61 88.67,51.98 88.67,52.12 88.87,52.32 89.1,52.32 90.58,50.84 91,50.84 91.13,50.7 91.13,50.5 90.7,50.07 90.7,49.92 90.84,49.78 90.99,49.78 91.42,50.21 91.63,50.21 92.45,49.38 93.24,49.38 93.33,49.29 93.33,48.9 93.42,48.81 93.68,48.81 93.81,48.94 93.81,49.33 93.91,49.43 94.11,49.43 94.21,49.33 94.21,48.89 94.32,48.79 94.73,48.79
  BOTTOM w0.089: U7.AV12 v1(79.37,63.68)
M_B_DQ24: length 28.4
  TOP w0.094: v3(98.17,51.55) 97.8,51.18 97.8,51.08 97.74,51.02 97.74,50.91 U27.C3
  IN1 w0.107: v1(91.39,57.84) 90.82,57.84 89.91,58.75 89.73,58.75 89.59,58.61 89.59,58.42 90.87,57.14 91.66,57.14 95.48,53.32 95.48,50.83 96.23,50.09 97.69,50.09 98.17,50.57 v3(98.17,51.55)
  BOTTOM w0.089: 83.62,61.08 83.88,61.34 83.88,61.35 84.07,61.54 84.35,61.54 84.41,61.48
  BOTTOM w0.094: U7.BD2 83.62,61.08 ; v1(91.39,57.84) 90.86,58.37 88.95,58.37 87.32,59.99 87.32,60.9 86.74,61.48 84.41,61.48
M_B_DQ25: length 29.7
  TOP w0.094: U27.C8 v3(101.8,50.97)
  IN1 w0.107: v3(101.8,50.97) 102.2,51.37 102.2,51.96 102.57,52.33 102.57,52.91 102.37,53.11 102.37,53.61 102.02,53.96 101.79,53.96 98.67,57.09 98.33,57.09 98.33,57.08 97.99,57.08 97.99,57.09 97.89,57.09 97.64,57.34 96.97,58.01 96.97,58.59 93.19,62.36 90.67,62.36 90.57,62.26 90.57,61.73 90.67,61.63 90.9,61.63 v1(91.33,61.2)
  BOTTOM w0.089: 85.14,64.03 84.61,64.03 84.45,64.18 U7.AV2
  BOTTOM w0.094: 85.14,64.03 85.75,63.41 87.59,63.41 88.91,62.09 89.79,62.09 89.99,61.89 90.64,61.89 v1(91.33,61.2)
M_B_DQ26: length 28.9
  TOP w0.094: v3(98.11,53.15) 97.82,52.86 97.82,52.59 U27.A3
  IN1 w0.107: v3(98.11,53.15) 96.48,53.15 96.35,53.02 96.35,52.57 96.57,52.35 97.47,52.35 97.61,52.21 97.61,51.93 97.48,51.8 96.96,51.8 96.85,51.7 96.85,51.48 96.94,51.38 97.66,51.38 97.87,51.18 97.87,50.78 97.58,50.49 96.3,50.49 95.76,51.02 95.76,53.44 92.07,57.13 v1(92.07,57.84)
  BOTTOM w0.089: U7.BC1 84.44,61.88 84.64,61.67
  BOTTOM w0.094: 84.64,61.67 86.82,61.67 87.51,60.98 87.51,60.07 88.95,58.64 91.63,58.64 92.07,58.21 v1(92.07,57.84)
M_B_DQ27: length 30.5
  TOP w0.094: v3(101.8,51.74) 101.42,51.37 U27.B8
  IN1 w0.107: v1(92.04,61.2) 92.04,61.53 91.93,61.64 91.29,61.64 91.14,61.78 91.14,61.97 91.26,62.08 92.51,62.08 93.08,62.08 96.69,58.47 96.69,57.9 97.44,57.14 97.78,56.81 98.55,56.81 101.68,53.68 101.84,53.68 102.1,53.43 102.1,52.99 102.29,52.8 102.29,52.48 102.07,52.25 101.75,52.25 101.62,52.39 101.38,52.39 101.26,52.27 101.26,52.07 101.59,51.74 v3(101.8,51.74)
  BOTTOM w0.089: U7.AV3 83.41,64.18 83.71,64.48 83.95,64.48 84.05,64.38 84.53,64.38 84.64,64.27 85.22,64.27
  BOTTOM w0.094: 85.22,64.27 85.88,63.61 87.79,63.61 89.02,62.37 89.9,62.37 90.11,62.17 91.07,62.17 v1(92.04,61.2)
M_B_DQ28: length 29.6
  TOP w0.094: v3(100.99,52.63) 100.99,52.94 100.7,53.23 100.48,53.23 100.38,53.14 100.38,52.26 100.47,52.17 U27.A7
  IN1 w0.107: v3(100.99,52.63) 100.76,52.63 100.65,52.73 100.65,53.46 100.7,53.51 100.7,54.26 98.44,56.53 97.66,56.53 97.24,56.95 96.41,57.78 96.41,58.36 94.17,60.59 93.93,60.59 93.82,60.7 93.82,60.93 93.72,61.03 93.52,61.03 93.42,60.93 93.42,60.7 93.32,60.59 93.11,60.59 93.01,60.7 93.01,61.7 92.91,61.8 92.72,61.8 92.6,61.69 92.6,60.7 92.5,60.59 89.64,60.59 89.51,60.72 89.51,60.9 89.81,61.2 v1(89.9,61.2)
  BOTTOM w0.089: 85.14,63.7 84.66,63.7 84.38,63.98 84.05,63.98 83.96,63.89 83.56,63.89 83.47,63.8 U7.AW3
  BOTTOM w0.094: 85.14,63.7 85.64,63.2 87.39,63.2 88.77,61.81 89.29,61.81 v1(89.9,61.2)
M_B_DQ29: length 29
  TOP w0.094: v3(98.09,53.79) 97.69,53.79 96.6,52.7 96.6,52.17 U27.A2
  IN1 w0.107: v1(93.26,56.96) 93.26,56.38 94.25,55.39 94.48,55.39 95.22,56.13 95.37,56.13 95.51,55.99 95.51,55.85 94.71,55.05 94.71,54.91 94.84,54.78 95.02,54.78 95.8,55.56 95.94,55.56 96.09,55.42 96.09,55.27 95.39,54.57 95.39,54.31 95.94,53.77 96.23,53.77 96.7,54.24 96.7,54.55 96.8,54.65 97.13,54.65 97.25,54.53 97.25,53.56 97.37,53.43 97.74,53.43 v3(98.09,53.79)
  BOTTOM w0.089: 84.79,61.86 84.44,62.22 84.07,62.22 84.01,62.15 83.82,61.96 83.82,61.82 U7.BC2
  BOTTOM w0.094: v1(93.26,56.96) v1(93.26,58.53) 92.87,58.92 88.93,58.92 87.71,60.13 87.71,60.16 87.7,60.16 87.7,61.06 86.89,61.86 84.79,61.86
M_B_DQ30: length 27.8
  TOP w0.094: U27.D7 100.6,49.8 v3(100.22,50.18)
  IN1 w0.089: 100.66,51.13 100.66,50.85 100.27,50.47 100.27,50.46 100.22,50.41 v3(100.22,50.18)
  IN1 w0.107: v1(89.24,61.22) 89.24,61.02 89.23,61.02 89.23,60.8 89.13,60.7 88.74,60.7 88.49,60.45 88.49,60.31 88.83,59.98 88.96,59.98 89.12,60.13 89.3,60.13 89.48,60.31 94.05,60.31 96.13,58.24 96.13,57.67 97.04,56.75 97.54,56.25 98.32,56.25 100.42,54.15 100.42,53.62 100.38,53.58 100.38,52.44 100.48,52.33 100.64,52.33 100.74,52.23 100.74,52.03 100.55,51.84 100.55,51.68 100.81,51.42 100.81,51.28 100.66,51.13
  BOTTOM w0.089: 84.39,63.7 84.58,63.51 85,63.51
  BOTTOM w0.094: U7.AW1 84.39,63.7 ; v1(89.24,61.22) 88.96,61.49 88.79,61.49 87.28,63.01 85.5,63.01 85,63.51
M_B_DQ31: length 30.2
  TOP w0.094: v3(98.52,52.49) 98.52,52.07 98.62,51.97 98.62,51.45 97.97,50.8 97.97,50.6 97.6,50.23 96.99,50.23 96.9,50.32 96.84,50.32 U27.C2
  IN1 w0.107: v3(98.52,52.49) 98.56,52.53 98.56,54.06 98.38,54.24 97.75,54.24 97.57,54.41 97.57,54.85 97.47,54.95 96.98,54.95 95.3,56.63 95.1,56.63 94.36,55.9 94.21,55.9 94.09,56.02 94.09,56.2 94.81,56.92 94.81,57.13 93.97,57.97 93.7,57.97 93.53,57.79 93.53,57.57 93.92,57.17 v1(93.92,56.87)
  BOTTOM w0.089: U7.BB3 83.66,62.15 83.95,62.44 84.5,62.44 84.89,62.05
  BOTTOM w0.094: 84.89,62.05 86.97,62.05 87.89,61.13 87.89,60.32 89.01,59.2 93.2,59.2 93.94,58.45 93.94,56.89 v1(93.92,56.87)
M_B_DQ32: length 12.5
  BOTTOM w0.089: 78.69,59.48 78.4,59.19 78.4,58.95 78.48,58.88 78.48,58.53 78.38,58.43 78.38,57.75 78.73,57.4
  BOTTOM w0.094: U7.BG12 78.69,59.48 ; U34.A3 81.86,52.17 79.93,54.1 79.93,54.24 80.03,54.34 80.19,54.34 80.29,54.45 80.29,54.65 80.19,54.76 79.93,54.76 79.83,54.86 79.83,55.04 79.95,55.16 79.95,55.31 79.81,55.44 79.65,55.44 79.49,55.28 79.34,55.28 79.2,55.42 79.2,55.57 79.37,55.74 79.37,55.88 79.23,56.02 79.08,56.02 78.91,55.85 78.77,55.85 78.61,56.01 78.61,56.16 78.89,56.44 78.89,56.61 78.78,56.71 78.62,56.71 78.52,56.81 78.52,57.04 78.73,57.25 78.73,57.4
M_B_DQ33: length 12.5
  BOTTOM w0.089: 78.77,57.92 78.77,58.25 78.89,58.37 78.89,58.87 79.17,59.15 U7.BG11
  BOTTOM w0.094: U34.A2 83.04,52.75 83.04,53.06 82.89,53.21 82.75,53.21 82.23,52.69 82.01,52.69 81.88,52.82 81.88,53.02 82.23,53.37 82.23,53.52 82.07,53.68 81.91,53.68 81.52,53.29 81.35,53.29 81.19,53.44 81.19,53.62 81.62,54.05 81.62,54.2 79.33,56.49 79.33,57.58 79.24,57.67 79.01,57.67 78.83,57.85 78.83,57.86 78.77,57.92
M_B_DQ34: length 14.4
  BOTTOM w0.089: U7.BG17 76.33,59.5 76.46,59.5 76.55,59.41 76.55,59.28 76.46,59.19 76.46,59.09 76.37,59 76.11,59 75.99,58.88 75.99,58.51 76.01,58.49 76.01,58.22 ; U34.B8 79.03,51.37 79.11,51.28 79.11,50.97 79.03,50.88 78.66,50.88 78.38,51.15 78.38,51.44 78.18,51.64 78.18,51.76 78.29,51.87 78.47,51.87 78.56,51.78 79.04,51.78 79.13,51.87 79.13,52.04 79.13,52.44 79.18,52.5 79.18,52.71
  BOTTOM w0.094: 79.18,52.71 78.97,52.93 77.59,52.93 77.5,53.03 77.5,53.76 77.15,54.11 77.14,54.11 77.13,54.12 76.88,54.12 76.78,54.22 76.78,54.94 76.22,55.5 76.22,55.83 76.27,55.88 76.27,55.88 76.38,56 76.38,57.01 76,57.4 76,57.61 76.1,57.71 76.22,57.71 76.33,57.81 76.33,58.02 76.23,58.11 76.11,58.11 76.01,58.22
M_B_DQ35: length 12.8
  BOTTOM w0.089: U7.BJ17 76.26,58.43 ; 79.39,52.8 79.39,52.38 79.31,52.3 79.31,52.04 79.49,51.85 79.49,51.68 79.31,51.5 79.31,51.24 79.45,51.09 79.45,50.91 79.3,50.76 79.3,50.61 78.95,50.25 78.95,50.09 79.05,49.98 79.2,49.98 79.44,50.23 79.62,50.23 79.76,50.09 79.76,49.91 U34.D7
  BOTTOM w0.094: 79.39,52.8 79.05,53.13 77.8,53.13 77.7,53.23 77.7,53.67 77.7,53.84 77.21,54.32 77.15,54.32 77.06,54.41 77.06,54.96 76.45,55.57 76.45,55.81 76.63,55.99 76.63,57.11 76.36,57.38 76.36,57.52 76.55,57.71 76.55,58.14 76.26,58.43
M_B_DQ36: length 11.3
  BOTTOM w0.089: U7.BH12 78.69,58.43 78.57,58.31 78.57,57.85
  BOTTOM w0.094: U34.C2 83.43,50.75 83.43,50.75 83.17,51.01 83.17,52.27 82.95,52.49 82.93,52.49 82.93,52.5 81.93,52.5 81.93,52.5 81.82,52.5 80.57,53.75 80.57,54.98 79.11,56.44 79.11,57.3 78.64,57.77 78.64,57.78 78.57,57.85
M_B_DQ37: length 10.4
  BOTTOM w0.089: U7.BJ13 78.2,57.59
  BOTTOM w0.094: U34.C3 82.82,50.57 82.11,50.57 81.84,50.84 81.84,51.9 79.72,54.02 79.72,54.61 78.32,56.01 78.32,57.48 78.2,57.59
M_B_DQ38: length 13.1
  BOTTOM w0.089: U34.C8 78.69,50.57 78.22,51.04 77.09,51.04 76.97,50.93 76.97,50.67 76.85,50.55 76.66,50.55 76.53,50.68 76.53,51.18 ; U7.BH18 75.77,57.31
  BOTTOM w0.094: 76.53,51.18 76.7,51.35 76.7,51.49 76.53,51.66 76.53,52.93 76.7,53.1 77.19,53.1 77.3,53.21 77.3,53.67 77.07,53.91 77.06,53.91 77.05,53.92 76.6,53.92 76.5,54.02 76.5,54.95 76.01,55.44 76.01,55.91 76.19,56.1 76.19,56.89 75.77,57.31
M_B_DQ39: length 13.1
  BOTTOM w0.089: 76.75,58.86 76.54,58.66 76.54,58.49 76.82,58.21
  BOTTOM w0.094: U34.A7 80.06,52.17 80.15,52.26 80.15,52.38 79.96,52.57 79.67,52.57 79.58,52.66 79.58,52.92 79.17,53.34 78.01,53.34 77.91,53.44 77.91,53.77 78.41,54.28 78.41,54.41 78.29,54.53 78.13,54.53 77.78,54.18 77.64,54.18 77.34,54.48 77.34,54.63 77.47,54.75 77.71,54.75 77.82,54.85 77.82,55 77.64,55.17 77.15,55.17 76.69,55.64 76.69,55.79 76.81,55.91 76.81,56.03 76.88,56.1 77.35,56.1 77.48,56.23 77.48,56.48 77.38,56.58 76.91,56.58 76.82,56.67 76.82,58.21 ; U7.BH16 76.75,58.86
M_B_DQ40: length 25.2
  TOP w0.094: v3(84.04,46.98) 83.62,46.57 U26.H8
  IN1 w0.089: 78.24,57.83 78.24,58.4 76.83,59.8 76.83,61.21 76.64,61.39 v1(76.24,61.39)
  IN1 w0.107: v3(84.04,46.98) 84.04,46.81 84.38,46.46 84.82,46.46 85.36,46.99 85.36,48.39 85.46,48.49 85.71,48.49 85.81,48.6 85.81,48.79 85.71,48.9 85.54,48.9 85.43,49 85.43,49.31 84.98,49.76 84.82,49.76 84.52,50.06 84.52,50.31 84.26,50.57 83.5,50.57 83.37,50.71 83.37,50.85 83.48,50.96 83.48,51.1 83.35,51.23 83.17,51.23 83.05,51.11 82.91,51.11 82.72,51.29 82.38,51.29 81.64,52.03 81.64,52.35 81.37,52.62 81.37,52.77 81.53,52.93 81.53,53.07 81.39,53.21 81.24,53.21 81.08,53.06 80.93,53.06 80.63,53.36 80.63,54.5 80.73,54.6 80.97,54.6 81.07,54.7 81.07,54.9 80.96,55.01 80.73,55.01 80.63,55.11 80.63,55.44 79.08,56.98 79.08,57.13 79.22,57.27 79.22,57.41 79.08,57.55 78.92,57.55 78.79,57.41 78.65,57.41 78.24,57.83
  BOTTOM w0.089: U7.BC18 76.18,61.44 v1(76.24,61.39)
M_B_DQ41: length 25.7
  TOP w0.089: 82.57,46.84 82.82,46.6 U26.H7
  TOP w0.094: 82.57,46.84 82.26,47.15 v3(82.26,47.15)
  IN1 w0.089: 75.83,61.69 v1(76.24,62.1)
  IN1 w0.107: v3(82.26,47.15) 82.26,47.97 82.02,48.21 82.02,48.6 81.66,48.96 81.28,48.96 80.75,48.43 80.38,48.43 80.23,48.27 80.23,47.85 80.08,47.7 79.76,47.7 79.61,47.86 79.61,48.27 79.44,48.44 79.14,48.44 79.02,48.56 79.02,48.85 79.13,48.96 80.49,48.96 80.49,48.96 80.5,48.96 81.03,49.49 81.34,49.49 81.63,49.78 81.63,50.88 80.72,51.78 80.72,51.8 80.71,51.81 80.71,52.09 78.98,53.82 78.98,54.21 78.09,55.1 78.09,56.67 76.75,58.01 76.75,58.69 75.83,59.61 75.83,61.69
  BOTTOM w0.089: U7.BA18 v1(76.24,62.1)
M_B_DQ42: length 25.4
  TOP w0.094: U26.E3 79.61,48.97 v3(79.21,49.37)
  IN1 w0.089: 74.97,59.47 74.97,64.35 74.84,64.48 74.58,64.48 v1(74.33,64.24)
  IN1 w0.107: v3(79.21,49.37) 79.51,49.37 79.84,49.69 79.84,50.43 79.69,50.58 79.4,50.58 79.31,50.49 79.31,50.23 79.17,50.09 78.98,50.09 78.84,50.23 78.84,50.61 78.65,50.8 78.34,50.8 77.5,49.96 76.63,49.96 76.43,50.16 76.43,50.97 76.53,51.07 76.97,51.07 77.14,51.24 77.14,51.52 77.01,51.65 76.59,51.65 76.43,51.81 76.43,53.19 76.26,53.36 75.73,53.36 75.62,53.47 75.62,53.74 75.73,53.85 76.02,53.85 76.18,54.01 76.18,54.33 75.97,54.54 75.76,54.54 74.74,55.57 74.74,58.52 74.73,58.53 74.73,59.23 74.97,59.47
  BOTTOM w0.089: v1(74.33,64.24) 74.62,64.45 U7.AU20
M_B_DQ43: length 24.8
  TOP w0.094: U26.G2 78.83,47.37 v3(79.23,47.77)
  IN1 w0.089: 74.19,57.47 74.19,59.24 73.93,59.5 73.93,63.65 v1(73.34,64.24)
  IN1 w0.107: v3(79.23,47.77) 78.83,48.17 77.14,48.17 76.92,47.95 76.92,46.76 76.81,46.65 76.56,46.65 76.44,46.77 76.44,49.11 76.18,49.37 75.23,49.37 75.06,49.54 75.06,54.45 74.19,55.33 74.19,57.47
  BOTTOM w0.089: U7.AU22 v1(73.34,64.24)
M_B_DQ44: length 24.7
  TOP w0.094: v3(82.4,48.59) 82.82,48.17 U26.F7
  IN1 w0.089: 77.61,58.29 76.24,59.66 v1(76.24,59.97)
  IN1 w0.107: v3(82.4,48.59) 82.54,48.73 82.54,48.93 82.44,49.03 81.98,49.03 81.72,49.29 81.72,49.48 81.91,49.67 81.91,49.91 82.02,50.02 82.28,50.02 82.83,49.47 82.83,49.08 82.98,48.94 83.49,48.94 83.6,49.05 83.6,49.59 82.62,50.58 82.01,50.58 81.91,50.69 81.91,50.98 80.99,51.9 80.99,52.2 80.87,52.33 80.87,52.33 79.61,53.59 79.61,53.76 80.07,54.22 80.07,54.42 79.97,54.52 79.8,54.52 79.5,54.23 79.36,54.23 79.21,54.37 79.21,54.51 79.89,55.19 79.89,55.38 79.77,55.5 79.63,55.5 78.93,54.8 78.78,54.8 78.37,55.21 78.37,55.31 78.47,55.42 78.9,55.42 79.01,55.53 79.01,55.72 78.9,55.82 78.47,55.82 78.37,55.92 78.37,56.13 78.47,56.23 78.62,56.23 78.73,56.33 78.73,56.54 77.68,57.59 77.68,58.23 77.61,58.29
  BOTTOM w0.089: U7.BF18 v1(76.24,59.97)
M_B_DQ45: length 24.7
  TOP w0.094: U26.F8 83.6,48.17 v3(83.22,48.55)
  IN1 w0.089: v1(76.24,60.68) 76.64,60.28 76.64,59.66 77.62,58.68
  IN1 w0.107: 77.62,58.68 77.96,58.34 77.96,57.71 80.35,55.32 80.35,53.24 81.26,52.34 81.26,52.33 81.27,52.32 81.27,52.01 82.41,50.88 82.72,50.88 83.84,49.75 84.2,49.75 84.4,49.54 84.4,48.35 84.22,48.17 83.87,48.17 83.6,47.9 83.6,46.59 83.74,46.45 83.96,46.45 84.07,46.34 84.07,45.98 83.96,45.88 82.8,45.88 82.7,45.98 82.7,48.04 v3(83.22,48.55)
  BOTTOM w0.089: U7.BD18 v1(76.24,60.68)
M_B_DQ46: length 24.3
  TOP w0.094: v3(78.42,48.58) 78.82,48.19 U26.F2
  IN1 w0.089: 74.74,59.68 74.74,63.12 v1(74.33,63.53)
  IN1 w0.107: v3(78.42,48.58) 78.06,48.94 77.09,48.94 76.38,49.65 75.5,49.65 75.34,49.81 75.34,50.14 75.44,50.24 76,50.24 76.1,50.34 76.1,50.54 76,50.65 75.44,50.65 75.34,50.75 75.34,50.95 75.44,51.05 76,51.05 76.1,51.15 76.1,51.36 76,51.46 75.44,51.46 75.34,51.56 75.34,51.76 75.44,51.87 76,51.87 76.1,51.97 76.1,52.17 76,52.27 75.44,52.27 75.34,52.37 75.34,52.58 75.44,52.68 76,52.68 76.1,52.78 76.1,52.98 76,53.08 75.44,53.08 75.34,53.19 75.34,54.57 74.46,55.45 74.46,59.4 74.74,59.68
  BOTTOM w0.089: U7.AV20 74.62,63.74 v1(74.33,63.53)
M_B_DQ47: length 25.8
  TOP w0.094: U26.H3 v3(79.2,46.15)
  IN1 w0.089: v1(73.34,63.53) 73.75,63.12 73.75,58.52 73.91,58.36 73.91,57.47
  IN1 w0.107: 73.91,57.47 73.91,55.22 74.78,54.35 74.78,49.78 74.68,49.68 73.54,49.68 73.44,49.58 73.44,49.39 73.55,49.28 74.68,49.28 74.78,49.17 74.78,48.13 75.09,47.81 75.9,47.81 76.08,47.63 76.08,46.58 76.88,45.78 78.83,45.78 v3(79.2,46.15)
  BOTTOM w0.089: U7.AV22 v1(73.34,63.53)
M_B_DQ48: length 24.5
  IN2 w0.089: v3(81.87,47.59) 81.87,47.97 81.85,47.99 81.85,49.18
  IN2 w0.107: 81.85,49.18 81.74,49.29 81.74,50.84 79.97,52.62 79.18,52.62 77.88,53.92 76.51,53.92 76.37,54.06 76.37,54.25 76.47,54.35 77.3,54.35 77.41,54.46 77.41,54.65 77.31,54.76 76.5,54.76 76.4,54.86 76.4,55.06 76.5,55.16 77.13,55.16 77.23,55.27 77.23,55.46 77.12,55.57 76.74,55.57 76.64,55.67 76.64,56.54 75.6,57.58 74.75,57.58 74.33,57.99 74.33,58.25 74.44,58.35 74.94,58.35 75.04,58.45 75.04,58.66 74.94,58.76 74.25,58.76 74.13,58.88 74.13,59.07 74.24,59.19 74.48,59.19 74.58,59.29 74.58,59.73 v1(74.33,59.97)
  BOTTOM w0.089: U7.BF20 74.62,60.22 v1(74.33,59.97)
  BOTTOM w0.094: U34.H3 82.21,46.57 81.87,46.91 v3(81.87,47.59)
M_B_DQ49: length 25.4
  IN2 w0.089: v1(74.33,61.39) 75.1,60.63 75.1,59.93
  IN2 w0.107: v3(83.19,47.77) 82.83,48.12 82.83,51.5 82.91,51.57 82.91,52.01 82.37,52.55 82.09,52.55 81.85,52.31 81.64,52.31 81.51,52.44 81.51,52.63 81.97,53.09 81.97,53.24 81.77,53.45 81.62,53.45 81.37,53.2 81.23,53.2 81.09,53.35 81.09,53.49 81.72,54.12 81.72,54.26 80.98,55 80.83,55 79.91,54.08 79.77,54.08 79.63,54.22 79.63,54.38 80.58,55.32 80.58,55.47 78.87,57.18 78.5,57.18 77.82,56.5 77.48,56.5 76.72,57.25 76.72,58.15 75.1,59.78 75.1,59.93
  BOTTOM w0.089: U7.BC20 74.62,61.6 74.39,61.44 v1(74.33,61.39)
  BOTTOM w0.094: U34.G2 83.22,47.77 v3(83.19,47.77)
M_B_DQ50: length 24.3
  IN2 w0.089: 74.05,57.83 74.05,58.38 73.93,58.5 73.93,62.22 v1(73.34,62.81) ; 80.58,50.45 80.26,50.13 80.26,50.06 80.26,50.06 80.26,49.91 80.26,49.74 80.33,49.67 v3(80.33,49.34)
  IN2 w0.107: 80.58,50.45 80.58,50.45 80.58,50.45 80.58,50.77 80.36,51 80.21,51 78.67,52.54 78.67,52.54 78.32,52.89 78.31,52.89 78.13,53.07 76.61,53.07 76.42,52.88 76.42,52.16 76.32,52.05 76.14,52.05 76.01,52.18 76.01,55.2 76.19,55.37 76.19,56.59 75.48,57.3 74.92,57.3 74.79,57.17 74.79,56.84 74.69,56.74 74.42,56.74 74.31,56.85 74.31,57.57 74.05,57.83
  BOTTOM w0.089: U7.BA22 73.57,62.66 v1(73.34,62.81)
  BOTTOM w0.094: U34.F8 79.23,48.58 79.82,48.58 80.33,49.09 v3(80.33,49.34)
M_B_DQ51: length 27
  IN2 w0.089: 70.98,58.41 70.98,58.55 71.74,59.31
  IN2 w0.094: v1(72.35,61.39) 71.89,61.39 71.74,61.24 71.74,59.31
  IN2 w0.107: 70.98,58.41 70.98,57.7 71.68,57 71.68,54.35 71.07,53.75 71.07,52.23 70.86,52.02 70.86,50.55 70.5,50.19 70.5,49.42 71.45,48.46 76.13,48.46 76.33,48.27 76.33,47.29 76.53,47.09 77.64,47.09 78.28,46.45 78.28,45.9 78.42,45.76 78.64,45.76 78.8,45.92 78.8,46.84 78.92,46.95 v3(79.23,46.95)
  BOTTOM w0.089: U7.BD24 v1(72.35,61.39)
  BOTTOM w0.094: v3(79.23,46.95) 78.84,46.57 U34.H8
M_B_DQ52: length 25.4
  IN2 w0.107: v1(74.33,60.68) 74.85,60.16 74.85,59.56 76.25,58.17 76.25,57.33 77.34,56.24 77.34,56.01 77.48,55.87 77.62,55.87 78.6,56.85 78.75,56.85 78.89,56.7 78.89,56.56 77.91,55.58 77.91,55.44 78.06,55.29 78.2,55.29 79.18,56.27 79.32,56.27 79.47,56.13 79.47,55.98 78.24,54.76 78.24,54.58 78.37,54.45 78.51,54.45 79.75,55.7 79.9,55.7 80.04,55.55 80.04,55.41 79.06,54.43 79.06,54.29 82.31,51.04 v3(82.31,49.44)
  BOTTOM w0.089: U7.BD20 74.62,60.89 v1(74.33,60.68)
  BOTTOM w0.094: v3(82.31,49.44) 82.79,48.97 U34.E3
M_B_DQ53: length 23
  IN2 w0.089: 77.9,58.54 76.81,58.54 75.5,59.85 75.5,60.94 v1(74.33,62.1)
  IN2 w0.094: 78.97,57.47 78.62,57.82 78.49,57.82 77.79,57.12 77.66,57.12 77.54,57.25 77.54,57.37 78.24,58.07 78.24,58.2 77.9,58.54
  IN2 w0.107: v3(84.01,48.55) 83.61,48.95 83.61,50.17 83.51,50.27 83.21,50.27 83.11,50.37 83.11,50.57 83.21,50.67 83.51,50.67 83.61,50.78 83.61,50.98 83.51,51.08 83.21,51.08 83.11,51.18 83.11,51.39 83.21,51.49 83.51,51.49 83.61,51.59 83.61,51.92 82.47,53.06 82.47,53.97 78.97,57.47
  BOTTOM w0.089: 84.01,48.55 84,48.55 U34.F2 ; v1(74.33,62.1) 74.62,62.31 U7.BA20
  BOTTOM w0.094: 84.01,48.55 v3(84.01,48.55)
M_B_DQ54: length 27.5
  IN2 w0.094: v1(72.35,59.97) 72.35,59.95 72.24,59.83 72.24,54.28
  IN2 w0.107: 72.24,54.28 72.31,54.21 72.31,52.4 71.51,51.61 71.51,50.26 71.74,50.03 72.17,50.03 72.28,49.93 72.28,49.26 72.38,49.16 72.58,49.16 72.68,49.26 72.68,49.93 72.78,50.03 72.99,50.03 73.09,49.93 73.09,49.26 73.19,49.16 73.39,49.16 73.49,49.26 73.49,49.93 73.6,50.03 73.8,50.03 73.9,49.93 73.9,49.26 74,49.16 74.21,49.16 74.31,49.26 74.31,49.93 74.41,50.03 76.69,50.03 76.99,49.73 76.99,48.33 77.15,48.17 79.91,48.17 80.24,47.83 80.67,47.83 80.68,47.84 v3(80.72,47.84)
  BOTTOM w0.089: U7.BF24 v1(72.35,59.97)
  BOTTOM w0.094: U34.F7 80.39,48.17 v3(80.72,47.84)
M_B_DQ55: length 26.2
  IN2 w0.094: 71.92,59.18 71.92,60.54 72.06,60.68 v1(72.35,60.68)
  IN2 w0.107: v3(80.54,47.29) 80.32,47.51 79.51,47.51 79.39,47.38 79.39,47.38 79.37,47.37 76.86,47.37 76.67,47.56 76.67,49.04 76.32,49.38 75,49.38 74.36,48.74 71.71,48.74 71.38,49.08 71.38,49.95 71.15,50.18 71.15,51.78 72.03,52.66 72.03,54.09 71.96,54.17 71.96,58.15 71.55,58.55 71.55,58.8 71.92,59.18
  BOTTOM w0.089: U7.BD26 v1(72.35,60.68)
  BOTTOM w0.094: v3(80.54,47.29) 80.36,47.11 80.36,46.81 80.12,46.57 79.62,46.57 U34.H7
M_B_DQ56: length 15.3
  TOP w0.089: U26.D7 83.18,50.13 83.18,51.34 83.13,51.39 83.13,52.22 83.13,52.22 83.13,52.3 83.12,52.3 83.12,52.31
  TOP w0.094: v1(75.15,56.23) 75.49,55.9 75.76,55.9 75.82,55.89 75.97,55.74 76.18,55.74 76.55,55.37 78.88,55.37 80.29,53.97 80.29,53.9 81.21,52.98 82.44,52.98 83.12,52.31
  BOTTOM w0.089: U7.BJ21 74.45,58.55 74.45,57.72
  BOTTOM w0.094: v1(75.15,56.23) 74.86,56.23 74.76,56.33 74.76,57.42 74.52,57.65 74.51,57.65 74.45,57.72
M_B_DQ57: length 16.6
  TOP w0.089: 79.32,53.43 80.37,52.38 80.37,51.53
  TOP w0.094: U26.C3 79.62,50.78 80.37,51.53 ; v1(73.92,54.62) 74.57,54.62 75.33,53.86 76.38,53.86 76.5,53.74 76.5,53.34 76.73,53.1 77.14,53.1 77.32,53.28 77.32,53.83 77.42,53.94 77.92,53.94 78.15,53.71 78.15,53.66 78.15,53.66 78.15,53.54 78.27,53.43 78.65,53.43 78.66,53.43 79.32,53.43
  BOTTOM w0.089: U7.BG25 72.37,59.13 72.66,58.85 72.66,58.24
  BOTTOM w0.094: v1(73.92,54.62) 73.55,54.62 72.68,55.49 72.68,57.34 72.59,57.43 72.59,58.18 72.66,58.24
M_B_DQ58: length 14.2
  TOP w0.089: U26.B8 83.44,51.37 83.31,51.5 83.31,52.3
  TOP w0.094: v1(75.78,56.33) 76.09,56.02 76.3,56.02 76.66,55.67 78.96,55.67 79.93,54.69 80.56,54.69 80.66,54.59 80.66,54.35 80.49,54.17 80.49,53.98 81.25,53.22 82.48,53.22 83.31,52.4 83.31,52.3
  BOTTOM w0.089: U7.BH20 74.89,58.99 74.89,57.88
  BOTTOM w0.094: 74.89,57.88 75.78,56.99 v1(75.78,56.33)
M_B_DQ59: length 16.3
  TOP w0.089: U26.A7 82.51,52.17 82.4,52.27 82.4,52.53 82.29,52.64 82.06,52.64 81.84,52.42 81.72,52.42 81.42,52.72 81.19,52.72 79.39,54.52
  TOP w0.094: v1(75.58,55.46) 75.85,55.46 75.86,55.46 75.92,55.46 76.02,55.36 76.02,55.19 76.11,55.1 78.79,55.1 79.37,54.52 79.39,54.52
  BOTTOM w0.089: 74.04,58.85 74.04,58.86 74.13,58.95 74.13,59.19 73.83,59.49 U7.BG22
  BOTTOM w0.094: 74.04,58.85 74.04,58.84 74.04,58.53 74.27,58.3 74.27,57.79 74.27,57.79 74.27,57.64 74.51,57.4 74.51,57.28 74.51,57.28 74.51,56.2 73.87,55.56 73.87,55.31 74.01,55.17 74.2,55.17 74.63,55.59 74.86,55.59 75.19,55.26 75.38,55.26 v1(75.58,55.46)
M_B_DQ60: length 17.4
  TOP w0.089: 76.33,52.67 76.41,52.67 76.49,52.59 77.51,52.59 77.61,52.7 79,52.7 79.25,52.45 79.25,51.24 79.42,51.07 79.42,50.9 ; U26.C2 78.98,50.41 79.16,50.41 79.26,50.5
  TOP w0.094: 79.42,50.9 79.26,50.74 79.26,50.5 ; 76.33,52.67 75.23,52.67 75.06,52.84 75.06,53.34 74.8,53.61 v1(73.72,53.61)
  BOTTOM w0.089: U7.BG26 72.06,59.61 72.06,59.32 72.18,59.19 72.18,58.93 72.06,58.81 72.06,57.64
  BOTTOM w0.094: 72.06,57.64 72,57.58 72,57.23 72.15,57.08 72.15,55.18 72.25,55.08 72.25,54.94 72.15,54.83 72.15,54.61 72.25,54.51 72.39,54.51 72.57,54.68 72.72,54.68 72.86,54.54 72.86,54.39 72.65,54.19 72.65,54.04 72.8,53.9 72.94,53.9 73.11,54.07 73.26,54.07 v1(73.72,53.61)
M_B_DQ61: length 17
  TOP w0.089: U26.A3 80.04,52.17 80.11,52.24 80.11,52.37 79.95,52.53 79.46,52.53 79.37,52.62 79.37,52.78 79.47,52.88 79.47,53.01 79.25,53.23 79.12,53.23 79.04,53.15 79.04,52.95 78.98,52.89 78.71,52.89 78.65,52.95 78.65,53.16 78.58,53.23 78.35,53.23 78.26,53.15 78.26,52.98 78.17,52.89 77.96,52.89 77.87,52.98 77.87,53.64 77.78,53.73 77.59,53.73 77.51,53.65 77.51,52.94 77.42,52.85
  TOP w0.094: v1(74.36,54.04) 74.76,54.04 75.34,53.46 75.34,53.11 75.45,53.01 75.75,53.01 75.83,53.09 75.83,53.48 75.94,53.58 76.14,53.58 76.23,53.5 76.23,53.06 76.37,52.93 76.44,52.93 76.44,52.92 76.52,52.92 76.6,52.85 77.42,52.85
  BOTTOM w0.089: U7.BJ25 72.37,58.41 72.28,58.33
  BOTTOM w0.094: v1(74.36,54.04) 73.76,54.04 72.4,55.4 72.4,57.22 72.28,57.34 72.28,58.33
M_B_DQ62: length 17.5
  TOP w0.089: U26.A2 78.82,52.35 78.68,52.49 77.77,52.49 77.68,52.4 76.89,52.4 76.86,52.37
  TOP w0.094: 76.86,52.37 76.75,52.26 76.75,52.1 76.66,52.01 76.48,52.01 76.39,52.1 76.39,52.32 76.31,52.41 76.13,52.41 76.04,52.32 76.04,52.1 75.95,52.01 75.77,52.01 75.68,52.1 75.68,52.32 75.6,52.4 75.2,52.4 74.74,51.94 74.5,51.94 74.34,52.1 74.34,52.24 74.78,52.69 74.78,53.2 74.66,53.33 74.41,53.33 v1(74.23,53.15)
  BOTTOM w0.089: U7.BH26 71.89,58.92 71.81,58.84 71.81,57.67
  BOTTOM w0.094: v1(74.23,53.15) 73.57,53.15 73.49,53.23 73.25,53.23 73.15,53.33 73.15,53.51 73.05,53.61 72.84,53.61 72.74,53.51 72.74,53.33 72.64,53.23 72.12,53.23 71.95,53.41 71.95,53.56 71.94,53.57 71.94,53.71 72.04,53.81 72.27,53.81 72.37,53.91 72.37,54.12 72.27,54.22 72.13,54.22 72,54.22 71.87,54.35 71.87,54.95 71.9,54.98 71.9,57.04 71.73,57.21 71.73,57.58 71.81,57.67
M_B_DQ63: length 15.8
  TOP w0.094: v1(75.35,56.83) 75.88,56.83 75.96,56.76 76.21,56.51 76.21,56.5 76.77,55.95 79.07,55.95 79.94,55.08 80.57,55.08 82.17,53.48 83.42,53.48 83.96,52.94 83.96,50.91 U26.C8
  BOTTOM w0.089: 74.67,57.8 74.67,58.78 74.49,58.96 74.49,59.26 U7.BG21
  BOTTOM w0.094: 74.67,57.8 75.07,57.41 75.07,57.12 v1(75.35,56.83)
M_B_DQSN0: length 33.7
  IN2 w0.089: 100.38,54.16 100.49,54.05 100.49,52.99 100.27,52.77 100.06,52.77 99.99,52.83 v3(99.99,53.08) ; v1(90.1,65.19) 90.1,64.99 90,64.89 89.77,64.89 89.66,65 89.66,65.53 89.78,65.65 90.97,65.65 91.26,65.37 91.26,65.07 91.95,64.38 91.97,64.38
  IN2 w0.14: 100.38,54.16 100.28,54.25 100.28,56.99 97.44,59.84 96.03,59.84 93.87,62 93.87,63.28 92.77,64.38 91.97,64.38
  BOTTOM w0.089: U33.B7 97.4,51.16 97.47,51.09 98.32,51.09 98.66,51.42 98.66,51.99 98.92,52.26 98.92,52.55 99.18,52.81 99.72,52.81 v3(99.99,53.08)
  BOTTOM w0.102: U7.AM3 83.31,67.28 83.59,67.28 83.69,67.39 83.7,67.39 83.71,67.39 83.95,67.39 84.12,67.22 85.05,67.22 85.35,66.92 85.36,66.92
  BOTTOM w0.127: 85.36,66.92 85.56,66.72 85.84,66.72 86.48,66.09 89.39,66.09 89.87,65.61 89.87,65.42 v1(90.1,65.19)
M_B_DQSN1: length 48.1
  IN1 w0.076: 103.11,47.49 103.09,47.49 103.05,47.45 100.8,47.45 100.58,47.68 100.58,47.96 99.98,48.56 99.58,48.56 99.4,48.39 99.4,48.07 99.33,47.99 99.2,47.99 99.07,47.87 99.07,47.76 99.21,47.62 v3(99.36,47.62)
  IN1 w0.089: 92.62,64.19 92.6,64.19 92.5,64.29 91.82,64.29 91.51,64.61 88.07,64.61 87.45,63.99 87.45,63.24 87.26,63.05 86.98,63.05 86.79,63.24 86.79,63.79 86.7,63.87 86.57,63.87 86.48,63.79 86.48,63.22 86.29,63.03 86.02,63.03 85.82,63.22 85.82,63.79 85.72,63.89 85.58,63.89 85.51,63.82 85.51,63.07 85.33,62.89 85.04,62.89 84.84,63.09 84.84,63.82 84.77,63.89 84.57,63.89 84.48,63.8 84.48,63.53 84.28,63.33 83.97,63.33 83.76,63.55 83.76,63.99 83.66,64.09 82,64.09 81.91,64 81.91,63.7 82,63.62 82.16,63.62 v1(82.22,63.68)
  IN1 w0.14: 103.11,47.49 103.13,47.49 103.27,47.64 103.27,48.14 104.52,49.4 104.52,53.85 103.27,55.1 102.8,55.57 102.41,55.57 98.15,59.83 98.08,59.83 93.71,64.19 92.62,64.19
  BOTTOM w0.089: U7.AV6 v1(82.22,63.68)
  BOTTOM w0.102: U33.G3 100.48,47.49 99.93,47.49 99.88,47.54 99.71,47.54 99.62,47.62 v3(99.36,47.62)
M_B_DQSN2: length 40.6
  TOP w0.089: v1(98.21,47.88) 98.1,47.99 97.97,47.99 97.69,47.71 97.46,47.71 97.4,47.65 U27.G3
  IN2 w0.089: v1(78.66,64.67) 78.88,64.45 78.88,64.31 79.11,64.08 83.1,64.08 83.45,63.72 83.45,63.48 85.45,61.48 85.45,61.47 85.49,61.43 85.49,61.4 85.49,61.39 ; 94.43,49.81 94.47,49.81 94.53,49.87 94.54,49.87 96.06,49.87 96.19,49.74 96.33,49.74 97.43,48.65 97.43,48.29 97.7,48.02 98.07,48.02 v1(98.21,47.88)
  IN2 w0.14: 85.49,61.39 85.5,61.38 85.5,61.33 85.65,61.18 85.66,61.18 86.11,60.73 86.11,57.3 86.46,56.94 86.46,56.73 86.11,56.38 86.11,55.8 87.22,54.69 87.64,54.69 87.96,55.01 88.21,55.01 88.35,54.87 88.35,54.59 87.84,54.08 87.84,53.65 88.56,52.93 89.09,52.93 89.83,53.67 90.05,53.67 90.24,53.49 90.24,53.29 89.87,52.92 89.87,52.45 90.19,52.13 90.62,52.13 91.45,52.96 91.68,52.96 91.86,52.78 91.86,52.58 91.08,51.8 91.08,51.38 91.43,51.03 91.85,51.03 92.59,51.77 92.83,51.77 93.01,51.59 93.01,51.39 92.29,50.68 92.29,50.16 92.65,49.81 94.43,49.81
  BOTTOM w0.089: v1(78.66,64.67) U7.AT13
M_B_DQSN3: length 29.6
  TOP w0.127: U27.B7 100.64,51.37 v3(101.04,50.97)
  IN1 w0.089: v3(101.04,50.97) 101.38,50.63 101.38,50.02 101.15,49.79 100.84,49.79 100.84,49.8 100.73,49.8 100.56,49.63 99.99,49.63 99.94,49.68 99.88,49.68 99.66,49.89 99.66,50.43 98.79,51.3 98.79,51.59 98.68,51.7 98.68,51.72
  IN1 w0.14: 98.68,51.72 98.68,51.99 98.95,52.26 98.95,54.32 97.94,55.33 97.14,55.33 96.38,56.09 95.21,57.26 95.21,57.82 94.61,58.42 93.43,58.42 93.29,58.27 91.1,58.27 90.71,58.67 90.71,59.53 v1(90.61,59.63)
  BOTTOM w0.102: 88.53,61.07 88.53,61.09 88.53,61.11 88.52,61.13 88.52,61.15 87.15,62.52 85.29,62.52 84.81,63.01 84.05,63.01 83.77,62.73 U7.BA3
  BOTTOM w0.127: 88.53,61.07 88.53,60.87 89.06,60.33 90.46,60.33 90.86,59.94 90.86,59.74 90.74,59.63 v1(90.61,59.63)
M_B_DQSN4: length 12
  BOTTOM w0.089: 77.62,57.74 77.62,57.93 77.63,57.94 77.63,58.27 77.51,58.39 77.51,58.84 77.23,59.12 U7.BG15
  BOTTOM w0.102: U34.B7 79.79,51.19 80.67,51.19 81.02,51.55 81.02,51.84 79.01,53.85 79.01,54.15 79,54.16 78.17,55 78.17,55.08 77.73,55.52 77.73,56.79 77.65,56.87 77.21,56.87 77.01,57.07 77.01,57.47 77.2,57.66 77.54,57.66 77.62,57.74
M_B_DQSN5: length 23.4
  TOP w0.089: v3(81.23,49.92) 81.09,49.79 81.09,49.24 80.37,48.52 80.37,48.09 79.89,47.61 79.71,47.61 79.62,47.53 U26.G3
  IN1 w0.089: 75.62,58.91 75.57,58.91 75.39,59.1 75.39,65.03 74.94,65.48 74.52,65.48 v1(74.33,65.66) ; 79.85,51.23 79.86,51.23 79.91,51.18 80.2,51.18 80.42,51.18 80.82,50.79 80.82,50.53 81.04,50.3 81.04,50.11 v3(81.23,49.92)
  IN1 w0.14: 75.62,58.91 76.04,58.5 76.04,57.78 76.49,57.33 76.49,54.96 77.68,53.77 77.68,52.88 79.33,51.23 79.85,51.23
  BOTTOM w0.089: U7.AT20 v1(74.33,65.66)
M_B_DQSN6: length 24.6
  IN2 w0.089: 72.61,58.41 72.61,58.43 72.7,58.52 72.7,58.89 72.75,58.94 72.75,61.65 72.99,61.89 73.13,61.89 v1(73.34,62.1)
  IN2 w0.14: 72.61,58.41 72.61,56.96 72.61,54.44 72.88,54.17 72.88,51.92 73.16,51.64 73.16,50.91 73.61,50.45 74.2,50.45 74.68,50.94 78.32,50.94 79.62,49.64 79.62,49.09 80.33,48.38 80.9,48.38 v3(81.37,47.92)
  BOTTOM w0.089: U7.BC22 v1(73.34,62.1) ; v3(81.37,47.92) 81.55,48.1 81.64,48.1 81.64,48.1 81.94,48.1 82.36,47.68 82.8,47.68 82.82,47.67 82.82,47.37 U34.G3
M_B_DQSN7: length 16.3
  TOP w0.076: 78.19,54.74 78.21,54.74 78.23,54.71 78.83,54.71 79.15,54.39 79.19,54.39 81.28,52.31 81.28,51.95 81.4,51.83 81.79,51.83 82.07,51.54 82.07,51.4 82.47,51 82.67,51 82.82,51.15 U26.B7
  TOP w0.127: v1(73.45,56.63) 73.45,56.53 73.55,56.43 74.32,56.43 74.99,55.76 74.99,55.42 75.68,54.74 78.19,54.74
  BOTTOM w0.089: 73.93,57.07 73.93,57.06
  BOTTOM w0.102: U7.BG23 73.52,59.25 73.52,58.96 73.64,58.84 73.64,58.36 73.72,58.27 73.72,58.27 73.74,58.25
  BOTTOM w0.127: v1(73.45,56.63) 73.45,56.58 73.61,56.41 73.82,56.41 73.93,56.52 73.93,57.06 ; 73.74,58.25 73.76,58.23 73.76,57.34 73.93,57.18 73.93,57.07
M_B_DQSP0: length 33.6
  IN2 w0.089: 91.97,64.65 91.93,64.65 91.43,65.14 91.43,65.44 91.05,65.83 91.03,65.83 89.71,65.83 89.48,65.6 89.48,65.44 v1(89.23,65.19) ; 100.56,54.35 100.56,54.26 100.67,54.16 100.67,52.91 100.34,52.59 100.17,52.59 v3(99.97,52.39)
  IN2 w0.14: 91.97,64.65 92.88,64.65 94.13,63.39 94.13,62.11 96.14,60.1 97.55,60.1 100.55,57.1 100.55,54.37 100.56,54.35
  BOTTOM w0.089: v3(99.97,52.39) 99.73,52.63 99.26,52.63 99.1,52.47 99.1,52.18 98.83,51.91 98.83,51.35 98.39,50.91 97.47,50.91 97.4,50.83 U33.C7
  BOTTOM w0.102: U7.AM2 83.68,66.95 83.68,66.82 83.77,66.73 83.89,66.73 84.05,66.89 84.06,66.89 84.19,67.02 84.97,67.02 85.19,66.8 85.19,66.78 85.2,66.77
  BOTTOM w0.127: 85.2,66.77 85.47,66.51 85.75,66.51 86.39,65.87 89.3,65.87 89.65,65.52 89.65,65.1 89.56,65.01 89.41,65.01 v1(89.23,65.19)
M_B_DQSP1: length 48.1
  IN1 w0.076: 103.11,47.23 103.04,47.3 100.74,47.3 100.42,47.61 100.42,47.9 99.91,48.41 99.64,48.41 99.56,48.33 99.56,48.22 v3(99.87,47.92)
  IN1 w0.089: v1(81.51,63.68) 81.74,63.91 81.74,64.07 81.93,64.26 83.74,64.26 83.93,64.07 83.93,63.62 84.05,63.51 84.21,63.51 84.3,63.6 84.3,63.87 84.5,64.07 84.85,64.07 85.02,63.89 85.02,63.16 85.12,63.06 85.26,63.06 85.33,63.14 85.33,63.89 85.51,64.07 85.79,64.07 86,63.86 86,63.3 86.09,63.2 86.22,63.2 86.3,63.29 86.3,63.86 86.5,64.05 86.77,64.05 86.97,63.86 86.97,63.32 87.06,63.22 87.18,63.22 87.27,63.31 87.27,64.06 88,64.79 91.58,64.79 91.89,64.47 92.57,64.47 92.59,64.46 92.62,64.46
  IN1 w0.14: 103.11,47.23 103.24,47.23 103.54,47.53 103.54,48.03 104.79,49.29 104.79,53.96 102.92,55.84 102.52,55.84 98.26,60.09 98.19,60.09 93.82,64.46 92.62,64.46
  BOTTOM w0.089: v1(81.51,63.68) U7.AV7
  BOTTOM w0.102: v3(99.87,47.92) 99.87,47.82 100.01,47.68 100.46,47.68 100.6,47.82 U33.F3
