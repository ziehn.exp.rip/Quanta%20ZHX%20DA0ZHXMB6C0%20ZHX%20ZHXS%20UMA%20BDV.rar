# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_HOLD_RST#_Q: length 8.1
  TOP w0.089: v1(81.5,73.44) 81.91,73.03 83.21,73.03
  TOP w0.108: TP26.1 87.4,73.13 85.25,73.13 85.05,72.92 83.72,72.92 83.6,73.03 83.21,73.03
  BOTTOM w0.102: v1(81.5,73.44) 81.5,73.3 U7.Y6
DGPU_PWR_EN_Q: length 9
  TOP w0.089: v1(79.4,73.41) 79.79,73.02 81.67,73.02 81.83,72.86 82.96,72.86 83.03,72.79 83.21,72.79
  TOP w0.108: TP29.1 87.03,72.71 83.63,72.71 83.54,72.79 83.21,72.79
  BOTTOM w0.102: v1(79.4,73.41) 79.4,73.58 U7.V10
DGPU_PWROK_Q: length 6.9
  TOP w0.089: 80.42,73.72 v1(80.12,73.42)
  TOP w0.108: 80.42,73.72 80.83,74.13 85.94,74.13 TP24.1
  BOTTOM w0.102: v1(80.12,73.42) 80.12,73.59 U7.V9
DMIC_CLK: length 180.8
  TOP w0.127: v1(19.13,34.46) 18.41,33.74 18.41,33.05 19.24,32.21 19.24,27.98 22.31,24.91 22.31,20.87 21.6,20.16 20.28,20.16 16.92,16.81 C55.1 15.83,16.37 14.31,16.37 R83.1
  IN2 w0.127: v1(19.13,34.46) 18.9,34.69 18.9,38.17 20.16,39.42 20.16,50.4 17.63,52.92 15.09,52.92 14.33,53.69 14.33,59.3 18.45,63.43 18.87,63.43 22.11,66.67 22.11,71.34 18.85,74.6 14.76,74.6 13.72,75.64 13.72,81.86 13.36,82.22 13.36,82.64 12.64,83.37 12.64,84.3 12.86,84.52 13.55,84.52 14.38,85.35 14.38,86.79 13.46,87.71 13.46,89.58 14.76,90.88 14.76,94.61 18.79,98.64 27.29,98.64 29.97,95.95 34.04,95.95 35.8,97.71 40.86,97.71 41.9,98.75 47.93,98.75 50.32,101.13 59.75,101.13 63.5,104.89 66.56,104.89 67.23,104.22 68.66,104.22 70.55,102.33 78.54,102.33 79.76,101.11 v1(79.76,98.9)
  BOTTOM w0.127: CN10.39 80.25,96.63 79.76,97.12 v1(79.76,98.9)
DMIC_CLK_R: length 1.7
  TOP w0.102: U4.3 12.59,16.4 12.82,16.63 R83.2
DMIC_DAT: length 184.7
  TOP w0.127: v1(19.23,33.65) v1(19.23,32.88) 19.49,32.62 19.49,28.09 22.56,25.02 22.56,20.76 21.7,19.91 20.38,19.91 17.02,16.55 C873.1 16.72,15.85 16.45,16.12 12.81,16.12 12.69,16 U4.2
  IN2 w0.127: v1(80.52,98.9) 80.52,100.71 78.64,102.58 70.65,102.58 68.76,104.47 67.34,104.47 66.66,105.15 63.4,105.15 59.64,101.39 50.21,101.39 47.83,99 41.79,99 40.76,97.96 35.69,97.96 33.94,96.21 30.1,96.21 27.41,98.89 18.69,98.89 14.51,94.72 14.51,90.98 13.21,89.68 13.21,87.6 14.13,86.68 14.13,85.46 13.45,84.78 12.75,84.78 12.38,84.41 12.38,83.26 13.11,82.54 13.11,82.11 13.47,81.75 13.47,75.53 14.65,74.35 18.74,74.35 21.86,71.23 21.86,66.77 18.77,63.68 18.34,63.68 14.07,59.41 14.07,53.58 14.99,52.67 17.48,52.67 19.9,50.24 19.9,39.53 18.64,38.27 18.64,34.23 v1(19.23,33.65)
  BOTTOM w0.127: CN10.40 80.75,96.76 80.52,96.99 v1(80.52,98.9)
DNBSWON#: length 88.6
  TOP w0.108: U9.123 130.3,40.57 130.42,40.69 130.42,42.14 130.28,42.28 129.82,42.28 129.53,42.57 129.53,43.81 v1(130.08,44.36)
  IN1 w0.14: v1(139.49,58.01) 139.49,58.25 134.8,62.94 134.8,66.21 135.32,66.74 135.32,67.86 134.54,68.65 133.89,68.65 132.47,70.07 131.87,70.07 131.44,70.5 131.44,71.19 130.59,72.05 129.86,72.05 129.04,72.86 122.39,72.86 120.94,74.32 119.14,74.32 118.26,73.44 115.38,73.44 114.67,74.15 114.67,78.21 112.91,79.97 109.42,79.97 108.15,81.24 106.2,81.24 105.72,80.76 104.32,80.76 104.04,81.04 101.55,81.04 100.54,80.03 99.96,80.03 99.77,80.22 99.77,81.1 98.2,82.67 v1(97.49,82.67)
  IN2 w0.14: v1(130.08,44.36) 130.59,43.85 131.64,43.85 132.53,44.74 132.53,45.22 132.92,45.62 132.92,46.27 132.87,46.32 132.87,49.65 132.91,49.69 132.91,50.73 135.48,53.3 136.41,53.3 138.07,54.97 138.91,54.97 139.49,55.55 v1(139.49,58.01)
  BOTTOM w0.108: v1(97.49,82.67) 97.09,82.28 U17.1
DPWROK_EC: length 90.8
  TOP w0.108: R178.1 v1(105.2,74.03) 105.45,73.77 109.45,73.77 111.54,71.69 118.35,71.69 119.69,70.35 119.69,67.3 120.74,66.25 123.01,66.25 123.53,66.77 123.53,67.26 123.6,67.33 130.69,67.33 131.51,66.51 131.51,66.34 132.37,65.48 132.61,65.48 137.01,61.08 145.15,61.08 145.88,61.81 145.88,62.86 146.59,63.57 147.36,63.57 147.68,63.24 147.68,60.92 148.41,60.2 148.58,60.2 v1(148.92,59.85) ; v1(141.2,32.47) 141.42,32.7 U9.83
  IN1 w0.14: v1(148.92,59.85) 149.05,59.73 149.05,57.18 148.01,56.14 148.01,49.21 147.68,48.88 147.68,43.72 142.04,38.09 142.04,35.11 141.72,34.78 141.72,32.99 v1(141.2,32.47)
DPY_1P24_PWR: length 15
  TOP w0.508: R334.1 55.42,77.48 C178.1 56.53,77.17 57.02,76.67 v1(57.41,76.67) 57.42,76.66 C179.1
  IN1 w0.508: v1(57.41,76.67) 57.41,76.95 57.81,77.36 58.85,77.36 59.54,76.67 60.81,76.67 61.92,75.57 64.29,75.57 64.85,76.12 v1(64.85,76.29)
  BOTTOM w0.254: v1(64.85,76.29) 65.1,76.04 U7.P40 65.2,75.73 U7.T40
DRAM_RCOMP0: length 4.7
  TOP w0.254: R422.1 70.91,59.75 70.93,59.77 70.93,62.3 70.61,62.62 70.61,62.65 v1(70.45,62.81)
  BOTTOM w0.254: U7.BA28 v1(70.45,62.81)
DRAM_RCOMP1: length 1.5
  TOP w0.254: v1(72.35,62.81) 71.74,63.43 R421.1
  BOTTOM w0.254: v1(72.35,62.81) U7.BA26
DRM_PWOK_C1: length 3.9
  BOTTOM w0.108: R470.2 106.66,84.93 v1(106.96,84.93) Q38.3 106.96,83.22 106.82,83.08 106.45,83.08 106.31,83.22 Q38.2
DRM_PWOK_C2: length 4.7
  BOTTOM w0.254: R463.2 v1(110.62,43.88) Q35.2 110.62,41.7 110.75,41.57 111.14,41.57 111.27,41.7 Q35.3
EC_107: length 7.8
  TOP w0.102: 138.53,41.75 138.53,41.54 138.02,41.03 137.78,41.03
  TOP w0.108: R1159.1 v1(137.8,44.64) 138.53,43.91 138.53,43.42 R1158.1 138.53,42.35 138.53,41.75 ; 137.78,41.03 137.23,40.48 136.83,40.48 136.7,40.35 U9.107
EC_114: length 1.2
  TOP w0.203: v1(133.77,38.4) 133.9,38.53 U9.114
EC_119: length 4.2
  TOP w0.108: R1163.2 132.61,42.88 132.03,42.3 v1(132.03,42.05) 131.9,41.92 U9.119
EC_122: length 4.5
  TOP w0.108: U9.122 130.7,40.44 130.63,40.5 130.63,42.51 R1165.2 R1164.2
EC_125: length 4.5
  TOP w0.108: U9.125 129.5,40.27 129.35,40.43 129.35,42.01 128.91,42.45 R1167.2 R1166.2
EC_FB_CLAMP: length 4.3
  TOP w0.108: R248.1 R244.1 144.49,29.95 v1(143.97,30.47) 143.59,30.47 143.42,30.3 U9.77
EC_FPBACK#: length 132
  TOP w0.108: v1(143.5,33.75) 143.35,33.9 U9.86
  IN1 w0.14: v1(40.26,23.66) 40.26,23.38 41.23,22.41 48.23,22.41 50.86,25.04 57.25,25.04 57.99,24.3 71.98,24.3 74.51,21.77 74.51,20.73 74.51,20.5 77.03,17.98 99.96,17.98 103.33,21.35 120.86,21.35 121.55,22.05 124.17,22.05 125.04,22.92 126.84,22.92 127.99,21.77 137.96,21.77 138.31,21.43 141.5,21.43 145.7,25.63 145.7,32.66 144.61,33.75 v1(143.5,33.75)
  BOTTOM w0.108: v1(40.26,23.66) 40.62,23.66 41.73,24.78 41.73,26.18 41.38,26.53 Q24.2
EC_OVERRIDE: length 178.7
  TOP w0.108: v1(138.3,34.94) 138.39,35.03 138.39,37.04 137.95,37.48 136.78,37.48 136.22,38.05 136.22,38.4 135.9,38.71 U9.109
  IN1 w0.14: v1(138.3,34.94) 138.39,34.94 139.62,36.17 139.62,39.8 141.06,41.25 141.06,43.5 141.05,43.52 141.05,45.43 142.31,46.7 142.31,47.56 144.77,50.02 144.77,58.46 144.37,58.86 144.37,64.23 142.77,65.83 142.77,69.96 139.61,73.12 139.61,73.97 137.9,75.67 137.9,77.44 135.73,79.61 132.82,79.61 132.46,79.25 127.84,79.25 126.56,80.54 121.75,80.54 120.35,81.94 115.95,81.94 113.86,84.03 110.19,84.03 109.36,84.86 103.12,84.86 102.49,85.49 101.8,85.49 100.93,86.35 99.34,86.35 95.79,89.9 93.1,89.9 90.29,92.71 90.29,93.14 87.02,96.41 85.29,96.41 84.28,97.41 84.28,98.35 83.94,98.69 82.45,98.69 81.47,97.71 78.17,97.71 77.28,98.6 61.7,98.6 61.01,99.28 v1(58.73,99.28)
  BOTTOM w0.108: v1(58.73,99.28) 58.29,99.28 57.17,98.16 55.53,98.16 55.3,98.39 55.3,100.39 54.28,101.41 44.93,101.41 41.07,97.55 35.74,97.55 34.27,96.08 33.53,96.08 v1(31.76,94.31) R295.2
EC_PWROK: length 131.5
  TOP w0.108: R161.1 103.13,76.14 103.75,76.14 v1(104.66,75.23) 105.9,73.99 109.56,73.99 111.65,71.9 118.44,71.9 119.9,70.44 119.9,67.41 120.85,66.47 122.92,66.47 123.31,66.86 123.31,67.35 123.51,67.54 130.78,67.54 131.81,66.51 v1(131.93,66.51) ; v1(110.55,37.43) 110.77,37.43 111.91,38.58 112.63,38.58 113.79,39.74 113.79,40.6 114.78,41.59 115.94,41.59 118.96,44.6 125.92,44.6 126.97,45.65 126.97,48.65 128.77,50.45 129.23,50.45 130.85,52.07 130.85,53.47 130.69,53.63 130.69,55.02 v1(130.91,55.24) ; U9.33 128.3,24.65 128.49,24.84 129.15,25.5 v1(132.7,25.5)
  IN1 w0.14: v1(132.7,25.5) 132.07,24.87 129.27,24.87 128.12,26.02 123.75,26.02 123.56,25.82 117.98,25.82 116.79,24.64 108.25,24.64 106.71,26.18 106.71,27.5 108.74,29.53 108.74,31.42 v1(109.28,31.96)
  IN2 w0.14: v1(130.91,55.24) 130.91,55.59 132.4,57.08 132.4,63.27 131.93,63.74 v1(131.93,66.51)
  BOTTOM w0.108: Q35.5 110.62,39.77 109.99,39.14 109.99,37.99 v1(110.55,37.43) 110.13,37.02 110.13,35.88 109.85,35.59 109.06,35.59 108.79,35.32 108.79,32.46 v1(109.28,31.96)
EC_RTC_RST: length 121.4
  TOP w0.108: v1(134.29,27.68) 134.71,27.68 138,30.96 141.36,30.96 141.5,31.1 U9.79
  IN1 w0.14: v1(95.6,88.29) 97,88.29 99.22,86.07 100.82,86.07 101.68,85.21 102.37,85.21 103,84.58 109.24,84.58 110.07,83.75 113.7,83.75 115.79,81.66 120.23,81.66 121.63,80.26 126.44,80.26 127.73,78.97 132.57,78.97 132.93,79.33 135.61,79.33 137.62,77.32 137.62,75.56 139.33,73.85 139.33,73.01 142.49,69.85 142.49,65.44 144.09,63.84 144.09,58.68 144.49,58.28 144.49,50.13 142.03,47.68 142.03,46.81 140.77,45.55 140.77,42.46 140.14,41.82 140.14,40.71 139.34,39.92 139.34,37.48 137.84,35.99 137.84,34.2 136.37,32.73 136.37,29.15 134.9,27.68 v1(134.29,27.68)
  BOTTOM w0.108: R1035.2 94.75,87.58 95.46,88.29 v1(95.6,88.29) 95.89,88.58 Q75.2 95.89,90.84 95.75,90.97 R1039.2 v1(94.79,91.53) 94.24,91.53 93.98,91.28 93.98,90.52
EC_SYS_SHDN#: length 3.4
  TOP w0.203: 143.74,29.3 143.14,29.9 U9.76
  TOP w0.254: 143.74,29.3 145.15,29.3 R1204.1
ECAGND: length 9.9
  TOP w0.203: 141.38,29.5 U9.75
  TOP w0.33: v1(140.53,28.41) 140.53,29.31 140.82,29.61 141.28,29.61 141.38,29.5
  BOTTOM w0.33: v1(140.53,28.41) 140.53,28.25 142.09,26.69 L10.2 142.56,27.2 C118.2 143.1,27.62 144.31,28.83 144.31,28.9 C121.1
EDP_AUX#_C: length 5.3
  TOP w0.114: v1(69.44,94.13) 69.24,94.33 69.24,94.67 69.05,94.86 69.05,95.06 R108.2
  BOTTOM w0.114: CN10.19 70.25,95.11 70.13,94.99 70.13,94.81 69.9,94.58 69.29,94.58 69.19,94.48 69.19,94.38 v1(69.44,94.13) 69.22,93.91 69.22,93.55 69.35,93.42 C70.1
EDP_AUX_C: length 5.2
  TOP w0.114: v1(68.76,94.13) 68.97,94.34 68.97,94.56 68.78,94.75 68.78,95.05 R104.2
  BOTTOM w0.114: CN10.18 69.75,95.14 69.87,95.02 69.87,94.92 69.79,94.85 69.18,94.85 68.92,94.59 68.92,94.29 v1(68.76,94.13) 68.96,93.93 68.96,93.51 68.86,93.42 C63.1
EDP_HPD: length 2.8
  TOP w0.108: R819.2 69.85,97.48 v1(69.64,97.26)
  BOTTOM w0.108: v1(69.64,97.26) 68.75,96.37 CN10.16
EDP_TX0#_C: length 2.2
  BOTTOM w0.114: C80.2 73.17,94.21 73.17,94.88 73.25,94.96 CN10.25
EDP_TX0_C: length 2.2
  BOTTOM w0.114: CN10.24 72.75,95.06 72.91,94.91 72.91,94.11 C79.2
EDP_TX1#_C: length 2.7
  BOTTOM w0.114: C812.2 71.24,93.73 71.24,93.84 71.65,94.25 71.65,94.99 71.75,95.09 CN10.22
EDP_TX1_C: length 2.7
  BOTTOM w0.114: C813.2 70.97,93.73 70.97,93.95 71.39,94.36 71.39,95 71.25,95.14 CN10.21
EEPROM_SCL: length 1.7
  BOTTOM w0.108: U35.18 TP49.1
EEPROM_SDA: length 5.9
  BOTTOM w0.108: U35.26 29.08,66.61 29.31,66.85 29.49,66.85 29.88,67.24 29.88,69.14 28.58,70.45 TP47.1
EMMC_CLK: length 44.6
  TOP w0.102: v1(82.94,78.25) 83.02,78.33 R362.2
  IN2 w0.14: v1(82.94,78.25) 83.35,78.25 84.26,79.15 87.62,79.15 88.02,79.56 95.96,79.56 97.52,78.01 97.69,78.01 98.4,77.29 99.58,77.29 101.07,75.8 102.6,75.8 103.06,75.34 109,75.34 109.82,76.16 111.42,76.16 111.91,76.65 111.91,78.15 112.9,79.15 113.86,79.15 115.06,77.94 117.65,77.94 117.75,77.85 118.68,77.85 119.18,77.35 119.18,76.44 v1(118.75,76.02)
  BOTTOM w0.064: v1(118.75,76.02) 119.14,76.41 U20.M6
EMMC_CLK_R: length 3.1
  TOP w0.102: v1(81.5,77.24) 81.82,76.91 83.1,76.91 83.57,77.37 R362.1
  BOTTOM w0.102: v1(81.5,77.24) 81.15,76.89 U7.M7
EMMC_CMD: length 50.7
  TOP w0.102: R500.2 118.28,78.06 117.96,77.74 117.96,76.95 118.25,76.66 v1(118.65,76.66)
  IN2 w0.102: 83.72,76.72 82.61,76.72 v1(82.22,76.33)
  IN2 w0.14: v1(118.65,76.66) 117.98,76.66 117.74,76.9 115.87,76.9 115.44,77.34 114.38,77.34 114.12,77.07 114.12,76.07 114.66,75.53 114.66,75.26 113.97,74.56 113.74,74.56 113.41,74.89 112.75,74.89 112.29,74.44 110.5,74.44 109.92,73.85 109.92,73.65 110.47,73.11 110.47,72.91 110.27,72.71 110.07,72.71 109.52,73.26 109.33,73.26 109.18,73.11 109.18,72.88 109.72,72.34 109.72,72.18 109.63,72.09 101.15,72.09 96.94,76.3 96.81,76.3 95.26,77.86 91.86,77.86 91.51,77.51 85.62,77.51 85.18,77.07 84.07,77.07 83.72,76.72
  BOTTOM w0.102: v1(118.65,76.66) 119,76.66 U20.M5 ; v1(82.22,76.33) U7.P6
EMMC_DATA_0: length 48.7
  IN2 w0.14: v1(112.66,78.17) 112.43,77.94 112.43,76.44 111.63,75.64 110.04,75.64 109.21,74.82 108.65,74.82 108.51,74.68 108.51,74.18 108.37,74.04 108.09,74.04 107.95,74.18 107.95,74.68 107.81,74.82 107.67,74.82 107.25,74.4 106.62,74.4 106.52,74.3 106.52,74.09 106.45,74.01 106.21,74.01 106.1,74.12 106.1,74.72 106,74.82 105.74,74.82 105.6,74.68 105.6,74.27 105.46,74.13 105.18,74.13 105.04,74.27 105.04,74.68 104.9,74.82 103.7,74.82 103.35,74.47 103.2,74.47 102.85,74.82 102.67,74.82 102.59,74.75 102.59,74.16 102.45,74.01 102.24,74.01 102.1,74.16 102.1,75.14 101.95,75.28 101.75,75.28 101.6,75.14 101.6,74.16 101.45,74.01 101.2,74.01 100.81,74.4 100.81,74.6 101.04,74.83 101.04,75.14 100.9,75.28 100.71,75.28 100.3,74.87 100.1,74.87 99.9,75.07 99.9,75.26 100.29,75.65 100.29,75.85 100.09,76.04 99.89,76.04 99.51,75.66 99.31,75.66 99.11,75.86 99.11,76.06 99.5,76.44 99.5,76.64 99.37,76.77 99.12,76.77 98.72,76.37 98.59,76.37 97.47,77.48 97.3,77.48 95.75,79.04 87.9,79.04 87.62,78.76 84.41,78.76 83.45,77.8 81.88,77.8 81.79,77.7 81.79,77.51 81.98,77.32 v1(82.22,77.32)
  BOTTOM w0.102: v1(82.22,77.32) 81.86,76.97 U7.M6 ; U20.A3 113.44,77.91 113.32,78.02 112.81,78.02 v1(112.66,78.17)
EMMC_DATA_1: length 47.3
  IN2 w0.14: v1(112.9,77.41) 112.9,76.16 111.98,75.24 110.19,75.24 108.39,73.43 108.39,73.03 108.25,72.89 107.97,72.89 107.83,73.03 107.83,73.74 107.69,73.88 107.49,73.88 107.34,73.73 107.34,73.04 107.2,72.9 106.92,72.9 106.78,73.04 106.78,73.48 106.64,73.62 106.36,73.62 106.22,73.48 106.22,73.04 106.08,72.9 105.8,72.9 105.66,73.04 105.66,73.62 105.55,73.74 105.28,73.74 105.14,73.59 105.14,73.07 104.98,72.91 104.78,72.91 104.67,73.01 104.67,74.06 104.68,74.07 104.33,74.42 103.89,74.42 103.55,74.07 103.2,74.07 103.07,73.94 103.07,73.57 103.24,73.4 104.07,73.4 104.21,73.26 104.21,73 104.1,72.89 102.71,72.89 102.57,73.03 102.57,73.48 102.43,73.62 102.15,73.62 102.01,73.48 102.01,73.03 101.87,72.89 101.59,72.89 101.45,73.03 101.45,73.48 101.32,73.62 100.78,73.62 97.31,77.09 97.14,77.09 95.58,78.65 91.46,78.65 91.28,78.47 84.63,78.47 83.48,77.32 v1(82.93,77.32)
  BOTTOM w0.102: U20.A4 112.9,77.41 v1(112.9,77.41) ; v1(82.93,77.32) U7.M4
EMMC_DATA_2: length 48.3
  IN2 w0.102: v1(80.8,76.33) 81.05,76.59 81.05,77.71 82.02,78.68 83.24,78.68 83.47,78.91
  IN2 w0.14: 83.47,78.91 84.62,80.06 84.73,80.06 84.83,79.96 84.83,79.64 84.97,79.5 85.25,79.5 85.39,79.64 85.39,79.93 85.48,80.02 85.59,80.02 85.83,80.25 92.44,80.25 92.62,80.08 96.18,80.08 97.73,78.53 97.9,78.53 98.62,77.81 99.8,77.81 100.88,76.73 106.95,76.73 107.08,76.61 107.08,76.43 106.95,76.31 103.28,76.31 103.14,76.18 103.14,75.99 103.28,75.86 108.78,75.86 110.02,77.09 110.23,77.09 110.64,76.69 111.19,76.69 v1(111.33,76.82)
  BOTTOM w0.102: v1(80.8,76.33) 80.47,75.87 80.47,75.86 80.44,75.84 U7.P9 ; v1(111.33,76.82) 111.55,76.6 111.84,76.6 111.94,76.7 111.94,76.97 112.05,77.08 112.21,77.08 112.31,76.98 112.31,76.67 112.39,76.6 113.06,76.6 113.37,76.91 U20.A5
EMMC_DATA_3: length 48.7
  IN2 w0.102: 84.26,77.38 83.98,77.38 83.52,76.93 82.1,76.93 v1(81.51,76.33)
  IN2 w0.14: 84.26,77.38 85.09,77.38 85.65,77.94 91.39,77.94 91.7,78.25 95.42,78.25 96.97,76.7 97.1,76.7 101.31,72.49 108.4,72.49 108.78,72.87 108.78,73.27 110.34,74.83 112.13,74.83 112.62,75.33 113.38,75.33 113.72,75.67 113.72,78.11 v1(113.17,78.66)
  BOTTOM w0.064: U20.B2 114.5,78.66 114.5,79.07 114.64,79.21 114.75,79.21
  BOTTOM w0.102: 114.75,79.21 115.19,79.21 115.34,79.36 115.34,80.21 115.21,80.34 115.03,80.34 114.9,80.21 114.9,79.83 114.78,79.71 114.61,79.71 114.49,79.83 114.49,80.22 114.38,80.34 114.21,80.34 114.09,80.22 114.09,79.46 113.97,79.34 113.8,79.34 113.68,79.46 113.68,79.65 113.55,79.78 113.37,79.78 113.17,79.58 v1(113.17,78.66) ; v1(81.51,76.33) U7.P7
EMMC_DATA_4: length 48.4
  IN2 w0.102: 83.79,75.78 83.74,75.73 82.6,75.73 v1(82.22,75.34)
  IN2 w0.14: 83.79,75.78 84.53,76.51 85.72,76.51 85.89,76.68 92.06,76.68 92.45,77.07 94.42,77.07 94.66,76.83 94.66,76.18 94.67,76.17 94.67,76.11 95.4,75.38 95.86,75.38 96.94,74.3 97.7,74.3 100.69,71.31 110.02,71.31 112.37,73.65 v1(113.11,73.65)
  BOTTOM w0.064: U20.B3 114,78.16 113.45,78.16 113.37,78.24 113.1,78.24 112.57,78.77
  BOTTOM w0.102: v1(113.11,73.65) 112.9,73.65 112.68,73.88 112.45,73.88 109.81,76.52 109.81,77.92 110.87,78.98 111.45,78.98 111.55,79.09 111.55,79.58 111.65,79.68 111.86,79.68 111.96,79.58 111.96,79.09 112.06,78.98 112.35,78.98 112.57,78.77 ; U7.T6 v1(82.22,75.34)
EMMC_DATA_5: length 48.5
  IN2 w0.102: v1(81.51,75.34) 82.1,75.94 83.44,75.94 83.63,76.12
  IN2 w0.14: 83.63,76.12 84.3,76.79 85.34,76.79 85.62,77.08 91.62,77.08 91.65,77.11 91.68,77.11 92.03,77.46 95.09,77.46 96.65,75.91 96.78,75.91 100.98,71.7 109.86,71.7 112.2,74.04 112.87,74.04 v1(113.13,74.31)
  BOTTOM w0.064: 113.44,77.65 114,77.65 U20.B4
  BOTTOM w0.102: 113.44,77.65 113.3,77.79 112.32,77.79 111.48,78.63 111.05,78.63 110.16,77.74 110.16,76.9 111.18,75.89 111.64,75.89 111.74,75.78 111.74,75.09 111.86,74.97 112.03,74.97 112.15,75.09 112.15,75.78 112.25,75.89 112.49,75.89 112.58,75.8 112.58,74.86 v1(113.13,74.31) ; U7.T7 v1(81.51,75.34)
EMMC_DATA_6: length 48.4
  IN2 w0.102: 83.36,79.21 83.11,78.96 81.92,78.96 80.82,77.87 80.82,77 80.24,76.42 80.24,75.49 v1(80.09,75.34)
  IN2 w0.14: 83.36,79.21 84.29,80.14 84.29,80.7 84.6,81 85.66,81 86,80.66 92.59,80.66 92.78,80.47 96.34,80.47 97.9,78.92 98.21,78.92 98.93,78.2 99.96,78.2 101.03,77.13 108.31,77.13 109.83,78.65 110.01,78.65 110.13,78.53 110.13,78.36 108.45,76.67 107.59,76.67 107.47,76.55 107.47,76.38 107.59,76.25 108.62,76.25 109.97,77.61 110.27,77.61 110.6,77.28 111.15,77.28 v1(111.38,77.51)
  BOTTOM w0.064: 113.29,77.16 114,77.16 U20.B5
  BOTTOM w0.102: U7.T10 v1(80.09,75.34) ; v1(111.38,77.51) 111.56,77.51 111.63,77.43 112.35,77.43 112.84,76.95 113.08,76.95 113.29,77.16
EMMC_DATA_7: length 48.4
  IN2 w0.102: v1(79.37,75.34) 79.85,75.82 79.85,76.36 80.62,77.13 80.62,77.97 81.84,79.19 82.96,79.19 83.29,79.52
  IN2 w0.14: 83.29,79.52 84.03,80.26 84.03,80.86 84.45,81.29 86.06,81.29 86.28,81.07 88.84,81.07 88.98,81.21 88.98,81.47 89.13,81.62 89.38,81.62 89.54,81.47 89.54,81.21 89.68,81.07 92.75,81.07 92.94,80.87 96.5,80.87 98.06,79.31 98.38,79.31 99.09,78.6 100.12,78.6 101.19,77.53 108.15,77.53 109.09,78.47 109.09,78.85 109.29,79.05 110.16,79.05 110.75,79.63 111.95,79.63 112.07,79.51 112.07,79.33 111.95,79.21 110.92,79.21 110.77,79.06 110.77,78.79 110.93,78.63 110.93,78.45 110.77,78.29 v1(110.77,77.77)
  BOTTOM w0.064: U20.B6 114,76.65 113.44,76.65
  BOTTOM w0.102: v1(110.77,77.77) 110.72,77.71 110.72,76.85 111.32,76.24 113.02,76.24 113.44,76.65 ; v1(79.37,75.34) 79.02,74.98 U7.T12
EMMC_RCLK: length 32.7
  TOP w0.108: v1(116.97,76.16) 116.53,76.61 R1017.2
  IN2 w0.14: v1(116.97,76.16) 116.97,75.92 116.6,75.55 115.9,75.55 115.36,75 115.14,75 113.25,73.12 112.58,73.12 110.25,70.79 100.48,70.79 97.49,73.78 96.72,73.78 95.68,74.82 95.23,74.82 94.17,75.87 93.41,75.87 v1(93.21,76.07)
  BOTTOM w0.108: v1(93.21,76.07) 92.8,76.07 v1(92.47,76.41) 92.2,76.68 R494.2 ; U20.H5 117.25,76.45 v1(116.97,76.16)
EXT_LED_1#: length 116.1
  TOP w0.108: v1(144.09,42.87) 144.09,38.74 v1(143.87,38.52) 143.25,37.9 U9.96
  IN1 w0.14: v1(90.78,102.71) 89.76,102.71 89.41,102.35 89.41,99.62 90.6,98.43 90.6,94.01 91.12,93.49 91.12,93.06 93.45,90.73 96.14,90.73 98.76,88.12 102.17,88.12 103,87.29 104.51,87.29 105.16,86.64 116.2,86.64 118.93,83.91 121.22,83.91 123.1,82.02 127.17,82.02 128.46,80.74 131.84,80.74 132.2,81.1 136.35,81.1 139.39,78.05 139.39,77.23 141.1,75.53 141.1,73.74 143.61,71.23 143.61,68.18 146.42,65.37 146.42,61.98 145.46,61.01 145.46,59.01 146.61,57.86 146.61,49.79 144.89,48.07 144.89,45.84 144.24,45.19 143.13,45.19 142.88,44.94 142.88,44.08 v1(144.09,42.87)
  BOTTOM w0.108: PQ38.5 90.27,103.22 v1(90.78,102.71) PR239.1
EXT_LED_1#_R: length 17.6
  BOTTOM w0.108: CN10.33 77.25,96.44 77.85,97.04 77.85,98.69 79.33,100.17 82.93,100.17 83.57,99.53 85.73,99.53 86.11,99.91 86.11,103.34 86.63,103.87 PQ38.3
EXT_LED_2#: length 118.7
  TOP w0.108: U9.97 140.7,40.42 142.61,42.33 v1(142.9,42.33) 142.9,42.32 v1(143.44,42.86)
  IN1 w0.14: v1(90.74,103.73) 90.35,103.73 89.13,102.5 89.13,99.51 90.32,98.31 90.32,93.9 90.84,93.38 90.84,92.94 93.33,90.46 96.03,90.46 99.29,87.19 100.02,87.19 100.39,87.56 101.2,87.56 101.38,87.39 101.38,86.7 102.03,86.05 102.72,86.05 103.35,85.42 109.59,85.42 110.42,84.59 114.11,84.59 116.2,82.5 120.58,82.5 121.98,81.09 126.79,81.09 128.08,79.81 132.22,79.81 132.58,80.17 135.96,80.17 138.46,77.67 138.46,76.85 140.17,75.14 140.17,73.36 143.33,70.2 143.33,68.07 146.14,65.25 146.14,62.09 145.18,61.13 145.18,58.9 146.33,57.75 146.33,49.91 144.61,48.19 144.61,45.95 144.12,45.47 143.01,45.47 142.6,45.06 142.6,43.7 v1(143.44,42.86)
  BOTTOM w0.108: PQ38.2 88.2,103.22 88.65,103.66 88.65,103.85 89.7,104.9 90.09,104.9 90.74,104.25 90.74,103.73 v1(90.74,103.73) 90.75,103.72 PR240.1
EXT_LED_2#_R: length 17.7
  BOTTOM w0.108: PQ38.6 89.67,102.46 88.9,101.69 86.74,101.69 86.32,101.27 86.32,99.82 85.82,99.32 83.48,99.32 82.84,99.95 79.41,99.95 78.07,98.61 78.07,96.95 77.75,96.64 CN10.34
EXT_LED_3#: length 108.4
  TOP w0.108: U9.98 140.3,40.35 141.35,41.41 v1(141.35,41.67) v1(144.12,44.44)
  IN1 w0.14: v1(144.12,44.44) 144.12,44.67 145.17,45.72 145.17,47.96 146.89,49.68 146.89,59.01 147.37,59.49 147.37,64.82 143.89,68.3 143.89,71.34 141.43,73.81 141.43,75.59 139.67,77.35 139.67,78.17 136.46,81.38 132.08,81.38 131.72,81.02 128.58,81.02 127.29,82.3 123.22,82.3 121.34,84.18 119.06,84.18 116.32,86.92 105.28,86.92 104.63,87.57 103.11,87.57 102.28,88.4 98.93,88.4 96.31,91.01 93.56,91.01 91.59,92.99 91.59,98.19 90.78,99 v1(90.78,99.91)
  BOTTOM w0.108: PR241.1 v1(90.78,99.91) 90.27,100.42 PQ39.5
EXT_LED_3#_R: length 14.3
  BOTTOM w0.108: PQ39.3 86.99,101.07 86.54,100.62 86.54,99.63 85.94,99.02 83.36,99.02 82.72,99.66 79.54,99.66 78.36,98.48 78.36,96.99 78.75,96.6 CN10.36
EXT_LED_4#: length 116.1
  TOP w0.108: U9.99 139.9,40.51 140.17,40.78 140.17,41.79 140.65,42.26 140.83,42.26 141.45,42.89 v1(141.76,42.89) 142.27,42.89 143.48,44.1 v1(143.48,44.5)
  IN1 w0.14: v1(90.76,100.93) 91.24,100.44 91.24,98.93 91.87,98.3 91.87,93.1 93.51,91.46 97.18,91.46 98.42,90.22 98.42,89.3 99.04,88.68 102.4,88.68 103.23,87.85 104.74,87.85 105.39,87.2 116.45,87.2 119.18,84.46 121.45,84.46 123.34,82.58 127.41,82.58 128.69,81.3 131.61,81.3 131.97,81.66 136.96,81.66 141.7,76.91 141.7,73.92 144.17,71.46 144.17,68.42 147.65,64.93 147.65,59.38 147.17,58.89 147.17,49.56 145.45,47.84 145.45,45.6 144.59,44.74 144.59,44.25 144.31,43.98 143.87,43.98 143.48,44.37 v1(143.48,44.5)
  BOTTOM w0.108: PR242.1 v1(90.76,100.93) 90.5,101.18 90.5,101.7 90.09,102.11 89.7,102.11 88.65,101.06 88.65,100.55 88.52,100.42 PQ39.2
EXT_LED_4#_R: length 15.2
  BOTTOM w0.108: CN10.37 79.25,96.41 78.58,97.08 78.58,98.39 79.63,99.44 82.63,99.44 83.27,98.81 88.94,98.81 89.67,99.54 PQ39.6
FAN1_PWM: length 2.7
  TOP w0.108: R256.2 124.84,24.6 v1(125.15,24.91) 125.74,25.5 U9.32
FAN2_PWM: length 2.4
  TOP w0.108: R255.1 124.5,25.9 U9.31
FB_CLAMP_REQ#_Q: length 3.2
  TOP w0.089: v1(78.63,71.47) 79.19,72.03 80.28,72.03 80.75,72.51 TP31.1
  BOTTOM w0.102: U7.AD13 v1(78.63,71.47)
FB_VCORE: length 7.8
  TOP w0.254: v1(41.73,62.02) 41.73,61.52 PR33.1 42.61,62.04 PR165.2
  BOTTOM w0.203: PU4.3 41.29,62.71
  BOTTOM w0.254: 41.29,62.71 41.71,62.3 41.71,62.04 v1(41.73,62.02) 41.73,61.99 41.78,61.94 41.78,60.31 42.27,59.83 42.27,59.78 42.47,59.58 PR30.2 42.77,59.18 PR32.1
FB_VGG: length 7.1
  TOP w0.203: PU6.3 122.34,50 121.54,49.21 v1(121.48,49.21) PR214.1 120.99,48.12 120.99,46.92 v1(121.26,46.65) 120.66,46.05 PR215.2
  BOTTOM w0.254: PR106.1 PR214.1 v1(121.48,49.21)
FST_SPI_D0: length 63.7
  IN2 w0.102: v1(86.42,73.58) 86.83,73.17 88.44,73.17 88.63,73.35 88.77,73.35
  IN2 w0.14: 88.77,73.35 91.5,73.35 91.56,73.29 94,73.29 94.67,72.62 95.32,72.62 97.09,72.62 100.01,69.71 111.02,69.71 112.69,71.38 113.44,71.38 114.53,72.46 118.76,72.46 119.62,73.33 122.4,73.33 122.6,73.52 123.7,73.52 124.02,73.84 124.02,74.09 124.26,74.34 v1(124.9,74.34)
  BOTTOM w0.102: R68.2 120.02,89.75 v1(121.14,88.64) 121.15,88.63 121.15,85.21 121.77,84.59 121.77,82.8 125.22,79.36 125.22,79.36 125.21,79.36 125.21,77.77 124.74,77.3 124.74,76.57 124.16,75.99 124.16,75.25 124.9,74.51 v1(124.9,74.34) ; U7.V2 84.54,73.9 84.62,73.99 86.02,73.99 v1(86.42,73.58)
FST_SPI_D1: length 73.4
  IN2 w0.102: 88.77,73.69 88.54,73.69 88.46,73.61 87.17,73.61 v1(87.13,73.58)
  IN2 w0.14: v1(122.9,74.05) 122.64,74.05 122.26,73.67 119.48,73.67 118.62,72.81 114.38,72.81 113.29,71.72 112.55,71.72 110.88,70.05 100.15,70.05 97.24,72.96 95.18,72.96 95.18,72.96 94.85,72.96 94.17,73.64 91.7,73.64 91.64,73.69 88.77,73.69
  BOTTOM w0.102: R85.2 105,89.25 104.63,88.87 104.63,87.92 105.11,87.44 105.69,87.44 106.17,86.96 106.73,86.96 108.92,84.78 v1(114.33,84.78) 114.66,84.45 116.69,84.45 123.39,77.74 123.39,77.11 122.83,76.54 122.83,75.35 122.67,75.19 122.67,74.29 v1(122.9,74.05) ; U7.V3 83.42,73.9 83.71,74.2 83.96,74.2 84.05,74.11 84.46,74.11 84.54,74.19 86.52,74.19 v1(87.13,73.58)
FST_SPI_D2: length 74.7
  TOP w0.108: v1(121.29,69.59) 121.67,69.97 122.57,69.97 123.34,70.74 v1(123.34,72.32)
  IN1 w0.14: v1(121.29,69.59) 120.77,69.07 116.04,69.07 115.46,68.49 111.06,68.49 106.87,72.69 98.41,72.69 97.36,73.74 97.12,73.74 96.57,73.19 94.73,73.19 94.35,73.57 91.24,73.57 90.37,74.44 87.3,74.44 86.79,74.94 v1(86.79,75.25)
  BOTTOM w0.102: U7.U1 84.45,74.39 84.5,74.44 85.99,74.44 v1(86.79,75.25)
  BOTTOM w0.108: R70.1 104.14,87.9 104.96,87.08 105.54,87.08 106.02,86.6 106.58,86.6 110.26,82.92 117.71,82.92 122.24,78.39 122.24,77.05 122.47,76.81 122.47,75.59 122.2,75.32 122.2,73.47 v1(123.34,72.32)
FST_SPI_D2_R: length 7
  BOTTOM w0.108: R70.2 104.14,89.36 R77.2 v1(106.68,90.26) 107.94,90.26 108.21,89.99 108.21,88.91 108.4,88.72 U5.3
FST_SPI_D3: length 63.9
  TOP w0.108: v1(120.71,68.3) 120.71,68.78 121.1,69.17 122.08,69.17 123.66,70.74 123.66,71.54 124.02,71.9 v1(124.02,72.32)
  IN1 w0.14: v1(86.15,75.3) 86.15,74.85 86.84,74.16 90.22,74.16 91.09,73.29 94.24,73.29 94.62,72.91 97.46,72.91 97.97,72.41 106.75,72.41 110.94,68.21 115.58,68.21 115.66,68.3 v1(120.71,68.3)
  BOTTOM w0.102: v1(86.15,75.3) 86.15,75 85.82,74.67 84.04,74.67 83.91,74.53 83.62,74.53 U7.U3
  BOTTOM w0.108: R84.1 120.48,86.99 120.48,81.84 124.08,78.25 124.08,76.85 123.49,76.26 123.49,74.98 124.02,74.45 v1(124.02,72.32)
FST_SPI_D3_R: length 3.7
  BOTTOM w0.108: R84.2 R92.2 118.73,87.98 v1(118.19,87.45) U5.7
FUSE1_1P05_PWR: length 1.2
  BOTTOM w0.254: U7.H10 U7.G10 80.21,79.26 v1(80.25,79.3)
FUSE3_1P05_PWR: length 11.3
  TOP w0.254: R326.1 76.84,85.55 C160.2 77.2,84.58 v1(76.91,84.29)
  IN1 w0.254: v1(76.24,76.76) 75.62,77.39 75.62,82.16 76.99,83.53 76.99,84.22 v1(76.91,84.29)
  BOTTOM w0.254: v1(76.24,76.76) U7.N18
FUSE_1P05_PWR: length 0.6
  BOTTOM w0.254: v1(75.38,75.34) 75.38,75 U7.U19
FUSE_1P8_PWR: length 0.7
  BOTTOM w0.305: v1(77.23,75.34) 77.23,75.34 U7.U16
GP_CAMERASB08: length 17.3
  IN2 w0.102: v1(63.43,73.43) 62.98,73.88 60.28,73.88 60.2,73.8
  IN2 w0.14: 60.2,73.8 59.36,73.8 59,74.16 57.86,74.16 57.09,74.93 53.91,74.93 53.43,75.42 50.89,75.42 50.01,76.3 v1(50.01,76.31)
  BOTTOM w0.102: U7.Y44 63.07,73.08 v1(63.43,73.43)
  BOTTOM w0.108: R123.2 R122.1 49.54,75.83 v1(50.01,76.31)
GP_CAMERASB09: length 19
  IN2 w0.102: v1(64.14,73.43) 63.73,73.03 62.55,73.03 62.05,73.52 59.92,73.52
  IN2 w0.14: 59.92,73.52 59.23,73.52 58.83,73.92 57.76,73.92 57.03,74.65 53.8,74.65 53.32,75.14 49.97,75.14 v1(49.95,75.12)
  BOTTOM w0.102: U7.Y42 63.78,73.08 v1(64.14,73.43)
  BOTTOM w0.108: v1(49.95,75.12) 49.95,74.81 R117.1 49.56,74.84 49.2,75.2 48.74,75.2 48.41,74.87 R116.2
GP_CAMERASB11: length 20.7
  IN2 w0.102: v1(64.84,73.44) 64.84,73.42 64.24,72.82 62.46,72.82 61.99,73.3 59.68,73.3 59.64,73.26
  IN2 w0.14: 59.64,73.26 59.63,73.24 59.06,73.24 58.62,73.68 57.6,73.68 56.87,74.41 53.7,74.41 53.26,74.86 50.75,74.86 50.53,74.63 49.11,74.63 v1(48.97,74.77)
  BOTTOM w0.102: U7.V40 65.2,73.79 64.85,73.44 v1(64.84,73.44)
  BOTTOM w0.108: R110.2 R111.1 48.97,74.07 v1(48.97,74.77)
GPIO0: length 3.1
  BOTTOM w0.108: U23.17 25.54,23.17 24.97,22.6 24.26,22.6 TP52.1
GPIO8: length 14.1
  TOP w0.108: v1(84.89,91.35) 84.89,91.74 85.24,92.09 85.24,95.8 v1(84.75,96.29)
  BOTTOM w0.108: R308.1 84.33,88.24 84.33,88.89 84.89,89.45 v1(84.89,91.35) ; v1(84.75,96.29) 84.75,96.07 81.99,93.31 C700.1 R42.1
GPIO8_R: length 18.4
  TOP w0.108: v1(75.77,94.58) 74.12,96.23 v1(71.55,96.23) 70.92,96.23 70.45,96.7 68.6,96.7 v1(68.12,97.17)
  BOTTOM w0.108: CN10.12 66.75,96.38 67.01,96.64 67.93,96.64 68.12,96.83 v1(68.12,97.17) ; v1(75.77,94.58) 75.77,93.39 76.53,92.62 78.21,92.62 78.29,92.71 79.49,92.71 80.85,94.07 R42.2
GPIO_SUS0: length 10
  BOTTOM w0.102: 55.67,71.63 56.19,71.11 57.93,71.11 58.26,70.78 58.76,70.78 58.86,70.68 59.09,70.68 59.39,70.98 U7.AD51
  BOTTOM w0.108: R23.1 52.49,74.55 53.2,74.55 53.42,74.33 v1(53.42,73.93) 53.42,73.5 54.48,72.44 R18.2 54.89,71.71 55.59,71.71 55.67,71.63
GPIO_SUS1: length 9
  BOTTOM w0.102: 56.38,72.24 57.07,71.54 57.79,71.54 58.34,70.99 58.35,70.98 58.83,70.98 58.84,70.99 U7.AD52
  BOTTOM w0.108: R30.1 53.04,75.28 v1(53.14,75.17) 53.93,74.39 53.93,73.69 R22.2 54.91,72.71 55.91,72.71 56.38,72.24
GPIO_SUS2: length 14.5
  IN2 w0.102: 54.83,69.47 55.03,69.27 59.53,69.27 v3(59.8,69.55)
  IN2 w0.14: 54.83,69.47 54.36,69.94 51.12,69.94 50.72,70.34 49.46,70.34 v1(48.69,69.57)
  BOTTOM w0.102: U7.AH50 59.8,69.51 v3(59.8,69.55)
  BOTTOM w0.108: R359.1 R367.2 48.41,69.29 v1(48.69,69.57)
GPIO_SUS3: length 14.6
  IN2 w0.102: 56.78,69.57 58.7,69.57 59.1,69.96 60.02,69.96 v1(60.46,69.53)
  IN2 w0.14: v1(48.96,70.55) 49.03,70.62 50.83,70.62 51.21,70.24 54.87,70.24 55.54,69.57 56.78,69.57
  BOTTOM w0.102: U7.AH48 60.93,69.05 v1(60.46,69.53)
  BOTTOM w0.108: R1007.2 48.57,70.16 v1(48.96,70.55) 49.54,71.13 R1008.1
GPIO_SUS4: length 10.8
  BOTTOM w0.089: 56.69,68.21 54.57,68.21 v1(54.33,67.97) 54.18,67.82 53.86,67.82 53.2,67.16 53.17,67.16
  BOTTOM w0.102: 56.82,68.34 57.46,68.98 58.01,68.98 58.14,68.84 58.76,68.84 58.85,68.75 58.91,68.75 58.91,68.75 59.08,68.75 59.08,68.75 59.11,68.75 59.4,69.04 U7.AH51
  BOTTOM w0.108: 56.82,68.34 56.69,68.21 ; 53.17,67.16 52.6,67.16 R131.2 52.2,66.77 51.78,67.18 51.17,67.18 50.75,66.77 R127.1
GPIO_SUS5: length 51
  TOP w0.108: v1(39.17,87.01) 39.68,87.01 v1(40.21,86.48) 40.21,83.63 41.02,82.82 46,82.82 47.09,81.73 47.09,73.25 46.71,72.86 45.87,72.86 45.53,72.52 45.53,70.17 47.32,68.38 47.32,67.15 47.56,66.9 48.97,66.9 49.39,67.33 v1(49.91,67.33)
  BOTTOM w0.102: 55.55,68.44 56.54,68.44 57.28,69.18 58.09,69.18 58.23,69.04 U7.AH52
  BOTTOM w0.108: Q16.3 32.87,89.55 33.65,88.77 38.14,88.77 38.83,88.08 38.83,87.34 v1(39.17,87.01) ; v1(49.91,67.33) 49.91,67.52 R97.1 50.55,67.66 50.55,67.55 50.67,67.43 51.21,67.43 51.55,67.77 R103.2 52.09,67.37 53.15,67.37 54.22,68.44 55.55,68.44
GPIO_SUS6: length 7.7
  BOTTOM w0.102: 55.33,68.66 56.35,68.66 57.07,69.38 58.17,69.38 58.31,69.25 58.76,69.25 58.86,69.34 59.14,69.34 U7.AG51
  BOTTOM w0.108: R1009.1 52.99,68.93 v1(53.09,68.82) 53.25,68.66 55.33,68.66
GPIO_SUS7: length 179.6
  IN1 w0.14: v1(38.56,54.8) 38.56,54.38 39.42,53.52 39.42,46.94 38.51,46.03 38.51,39.62 37.47,38.57 37.47,35.81 38.89,34.38 40.33,34.38 41.05,34.38 42.66,32.78 58.14,32.78 58.16,32.77 58.17,32.78 76.17,32.78 76.18,32.78 78.26,34.86 88.44,34.86 88.75,34.56 90.71,34.56 92.13,34.56 93.98,36.41 97.23,36.41 97.69,35.96 99.65,35.96 102.29,38.6 107.62,38.6 110.72,41.69 110.72,45.58 111.08,45.94 111.08,49.8 112.57,51.3 112.57,52.57 111.43,53.71 110.11,53.71 108.66,55.16 108.66,56.76 109.22,57.32 109.22,62.71 106.5,65.43 102.31,65.43 101.92,65.04 101.2,65.04 100.96,64.8 100.96,63.79 100.44,63.27 100.44,63.02 100.04,62.62 99.97,62.62 99.52,62.17 v1(99.52,61.97)
  BOTTOM w0.102: 55.14,68.88 56.21,68.88 56.92,69.59 58.53,69.59 U7.AG53
  BOTTOM w0.108: v1(99.52,61.97) 99.37,61.97 99.26,61.86 98.22,61.86 v1(98.07,62.02) 97.75,62.34 96.25,62.34 94.07,64.52 R1019.1 ; v1(38.56,54.8) 37.79,55.57 37.79,55.9 38.16,56.26 39.08,56.26 39.09,56.25 47.02,56.25 50.32,59.55 50.32,64.14 48.61,65.85 48.61,66.65 48.88,66.92 48.88,67.93 49.28,68.33 50.44,68.33 50.98,68.87 50.98,69.14 51.2,69.36 51.61,69.36 52.2,69.94 R1010.1 52.84,69.31 53.21,69.31 53.65,68.88 55.14,68.88
GPIO_SUS8: length 8.3
  BOTTOM w0.102: 55.14,69.4 55.17,69.37 56.04,69.37 56.68,70.01 U7.AF52
  BOTTOM w0.108: 55.14,69.4 R47.2 54.23,70.31 54.23,70.58 v1(53.49,71.31) 52.99,71.31 R64.1
GPIO_SUS9: length 8.8
  BOTTOM w0.102: 55.14,69.15 56.11,69.15 56.77,69.81 58.76,69.81 58.86,69.71 59.08,69.71 59.39,70.02 U7.AF51
  BOTTOM w0.108: 55.14,69.15 54.79,69.15 v1(54.64,69.31) 54.61,69.33 54.48,69.33 53.34,70.47 R93.2 52.84,71.08 R76.2
GPIO_SUS10: length 9.6
  BOTTOM w0.102: 55.14,71.5 55.15,71.5 55.51,71.5 56.79,70.22 58.75,70.22 58.86,70.32 59.15,70.32 U7.AE51
  BOTTOM w0.108: 55.14,71.5 54.89,71.5 R43.2 53.87,71.69 53.87,72.15 v1(53.39,72.63) 53.21,72.63 52.96,72.38 52.59,72.38 52.32,72.65 52.32,72.78 52.21,72.89 R48.1
GPIO_SUS11: length 7
  BOTTOM w0.102: U7.AC51 59.04,71.47 58.76,71.19 58.43,71.19 57.38,72.23
  BOTTOM w0.108: 57.38,72.23 57.02,72.59 57.02,73.42 55.88,74.57 54.88,74.57 R581.2
GPIOCF1_1P8_PWR: length 3.4
  TOP w0.508: v1(68.78,70.5) 68.79,70.51 C251.1
  BOTTOM w0.254: v1(76.33,67.35) 76.33,67.36 75.95,67.74 U7.AK18 75.69,67.48 v1(75.57,67.36) 75.19,67.74 U7.AK19 ; U7.AD33 68.39,70.89 68.66,70.62 v1(68.78,70.5) 68.71,70.43 68.39,70.11 U7.AF33
GPIOCF2_1P8_PWR: length 0.6
  BOTTOM w0.305: v1(76.33,73.64) 76.33,73.62 U7.Y18
GSENSOR_INT: length 19.8
  TOP w0.108: Q43.3 89.41,83.94 89.95,84.48 90.1,84.48 90.27,84.65 v1(90.48,84.65) 90.58,84.65 91.4,83.83 R489.1 91.91,82.98 R56.1 92.74,82.69 v1(92.74,82.08)
  IN2 w0.14: v1(81.01,80.66) 81,80.67 81,81.42 81.48,81.91 82.96,81.91 83.22,82.16 88.14,82.16 88.92,82.95 92.25,82.95 92.74,82.46 v1(92.74,82.08)
  BOTTOM w0.102: v1(81.01,80.66) 80.95,80.72 U7.C7
H_PROCHOT#: length 189.7
  TOP w0.127: PR172.2 37.32,65.23 v1(37.52,65.42) ; v1(109.09,28.51) 109.09,29.35 109.35,29.61 109.35,30.44 106.02,33.77 v1(104.24,33.77) 102.97,32.5 PQ12.3
  TOP w0.203: PR204.2 126.77,52.47 PU6.12
  TOP w0.254: v1(124.82,45.46) 125.86,45.46 126.32,45.92 126.32,50.01 126.98,50.67 PR204.2
  IN1 w0.14: v1(45.09,73.12) 44.83,73.12 44.26,72.55 44.26,67 43.4,66.14 42.28,66.14 41.59,66.83 38.93,66.83 v1(37.52,65.42) 37.01,64.91 34.42,64.91 33.94,64.43 33.94,63.64 35.59,61.99 35.59,58.13 37.21,56.51 37.21,54.77 38.74,53.24 38.74,47.22 36.94,45.41 36.94,44.65 35.79,43.5 35.79,35.78 38.39,33.18 40.55,33.18 41.99,31.74 42.21,31.51 76.69,31.51 76.95,31.78 77.45,32.27 91.8,32.27 93.69,34.17 95.82,34.17 96.06,33.93 96.34,33.93 97.74,33.93 97.96,34.15 103.87,34.15 v1(104.24,33.77)
  IN1 w0.254: v1(109.09,28.51) 109.09,29.05 111.06,31.01 113.57,31.01 114.14,31.58 114.14,32.6 114.81,33.26 115.52,33.26 117.05,34.8 119.6,34.8 120.96,36.15 122.98,36.15 126.58,39.75 v1(126.58,40.78)
  IN2 w0.254: v1(124.82,45.46) 124.82,42.73 126.58,40.97 v1(126.58,40.78)
  BOTTOM w0.127: R136.1 46.96,71.95 46.74,71.95 46.41,72.28 46.41,72.46 45.64,73.22 45.19,73.22 v1(45.09,73.12) ; v1(37.52,65.42) 37.62,65.32 PU4.12
  BOTTOM w0.254: v1(126.58,40.78) 126.58,41.12 126.69,41.24 Q40.3 ; PR128.1 102.76,26.1 106.6,26.1 109.02,28.51 v1(109.09,28.51)
HDD_INTA: length 76.7
  TOP w0.203: v1(119.51,27.96) 118.7,28.77 115.88,28.77 115.68,28.57 U21.9
  TOP w0.254: R578.2 v1(150.37,68.59) v1(149.25,68.59)
  IN1 w0.203: v1(119.51,27.96) 120.44,27.02 123.06,27.02 123.25,27.22 128.62,27.22 129.48,26.36 131.75,26.36 132.2,26.8 136.36,26.8 137.14,27.58 137.14,32.53 140.21,35.6 140.21,39.51 141.66,40.96 141.66,42.98 142.29,43.62 142.29,45.18 142.88,45.78 143.99,45.78 144.3,46.08 144.3,48.32 145.8,49.82 v1(145.8,50.65)
  BOTTOM w0.203: v1(149.25,68.59) 147.57,66.91 147.57,59.22 147.19,58.84 147.19,57.53 148.12,56.59 148.12,55.45 147.27,54.6 147.27,51.18 146.75,50.65 v1(145.8,50.65)
HDD_INTA_R: length 3.3
  TOP w0.254: CN9.18 v1(154.23,68.59) R578.1
HDMI_5V:
  vias: v1(14.02,84.17)
HDMI_HPD: length 9.4
  BOTTOM w0.108: CN2.19 8.78,83.84 9.36,84.42 v1(12.98,84.42) 13.82,84.42 VC1.1 C135.1 R10.2 16,84.65 16.14,84.79 Q2.2
HDMI_HPD_CON: length 54.4
  IN1 w0.14: v1(29.47,87.75) 28.91,88.31 v1(23.88,88.31)
  IN2 w0.14: v1(52.3,77.36) 51.89,77.36 50.75,78.5 50.75,81.7 50.6,81.85 50.6,84.47 48.32,86.75 42.7,86.75 42.49,86.96 41.28,86.96 40.46,87.77 29.49,87.77 v1(29.47,87.75)
  BOTTOM w0.102: 54.48,75.56 56.41,75.56 58.22,73.75 58.71,73.75 59.04,73.42 U7.W51
  BOTTOM w0.108: v1(23.88,88.31) 23.68,88.31 23.34,87.97 21.16,87.97 20.53,87.35 R19.1 17.23,87.76 Q2.3 ; 54.48,75.56 v1(53.72,76.32) 52.68,77.36 v1(52.3,77.36)
HDMI_SCLK: length 14.8
  TOP w0.102: Q1.3 18.45,82.66 18.38,82.59 18.21,82.59 17.78,83.02 v1(17.78,83.28)
  BOTTOM w0.102: v1(17.78,83.28) 17.78,83.48 17.52,83.75 R269.2 16.72,83.75 16.56,83.59 16.56,83.03 v1(16.23,82.69) 15.98,82.44 15.24,82.44 14.8,82.88 12.9,82.88 11.71,84.06 9.89,84.06 9.38,83.56 9.38,82.1 CN2.15
HDMI_SDATA: length 13.9
  TOP w0.102: Q1.6 19.75,82.2 19.56,82.39 v1(17.83,82.39)
  BOTTOM w0.102: v1(17.83,82.39) 17.47,82.75 R268.2 16.87,82.75 16.36,82.24 15.14,82.24 14.91,82.46 v1(14.63,82.46) 14.59,82.46 14.38,82.67 12.81,82.67 11.63,83.86 9.98,83.86 9.59,83.47 9.59,82.69 CN2.16
HP_AGND: length 23.5
  TOP w0.254: CN6.5 12.65,49.2 13.78,49.2 15.04,47.93 15.04,45.89 15.44,45.48 15.44,44.52 14.91,43.98 14.91,38.95 13.29,37.33 10.3,37.33 9.53,36.55 R321.1 8.64,37.56 CN6.7
HP_JD#: length 44.1
  TOP w0.254: R29.2 9.75,22.87 v1(10.06,23.18)
  IN1 w0.254: v1(10.06,23.18) 7.9,25.34 7.9,33.21 10.7,36.01 14.43,36.01 16.92,38.5 16.92,40.68 16.27,41.33 16.27,45.33 18.16,47.22 18.16,48.33 17.07,49.42 11,49.42 9.78,48.2 CN6.6
HPL: length 41.3
  TOP w0.203: U4.32 3.99,17.2 v1(3.53,16.74)
  BOTTOM w0.381: R21.2 16.19,44.44 16.25,44.38 C28.2 16.93,44.32 16.93,44.32 16.93,43.27 R26.1 16.33,42.67 16.33,40.97 16.97,40.32 16.97,39.27 14.78,37.07 v1(14.05,37.07) 13.89,36.92 8.54,36.92 8.15,36.54 8.15,35.48 8.15,35.17 2.84,29.85 2.84,17.43 v1(3.53,16.74)
HPL-1: length 1.3
  BOTTOM w0.381: R21.1 L3.2
HPL_SYS: length 5.5
  BOTTOM w0.381: CN6.1 v1(14.68,38.65) C27.1 15.52,39.49 15.52,40.15 15.62,40.25 L3.1
HPR: length 42.1
  TOP w0.203: v1(4.36,16.74) 4.42,16.8 U4.33
  IN1 w0.381: v1(4.36,16.74) 3.78,17.32 3.13,17.32 2.87,17.58 2.87,18.15 3.13,18.4 3.13,30.24 5.54,32.66 5.55,32.66 5.75,32.85 5.78,32.89 7.36,34.47 7.36,34.88 7.72,35.25 7.72,36.13 8.76,37.18 13.62,37.18 15.11,38.67 15.11,44.98 v1(14.91,45.19)
  BOTTOM w0.381: v1(14.91,45.19) R20.2 15.66,45.94 C25.2 16.93,45.94 16.93,46.59 16.88,46.63 R28.1
HPR-1: length 1.5
  BOTTOM w0.381: L2.2 R20.1
HPR_SYS: length 11.4
  BOTTOM w0.381: CN6.2 7.57,49.62 v1(13.72,49.62) 15.47,49.62 L2.1 16.35,49.77 C24.1
HUB_RREF: length 5.2
  TOP w0.254: R1121.2 33.6,60.03 32.92,59.35 31.78,59.35 v1(31.65,59.48) v1(31.01,59.48)
  BOTTOM w0.254: v1(31.01,59.48) 31.01,59.96 30.51,60.47 30.25,60.47 30.08,60.64 U35.8
HWPG: length 48.8
  TOP w0.203: U9.21 127.55,29.9 128.03,30.37 129.9,30.37 131.24,31.71 v1(131.52,31.71)
  TOP w0.254: v1(141.35,52.2) v1(139.87,50.73) 137.18,50.73 R481.1 136.26,51.48 135.68,50.89 D19.2 134.4,50.89 134.2,51.08 134.2,52.59 134.41,52.8 D20.2 135.68,52.8 135.84,52.96 135.84,54.6 135.74,54.7 D21.2 134.51,54.7 134.27,54.94 134.27,56.45 134.42,56.61 D18.2
  IN1 w0.254: v1(131.52,31.71) 133.71,33.9 133.71,35.99 133.43,36.27 132.89,36.27 132.73,36.43 132.73,38.88 134.62,40.77 134.62,41.69 136.69,43.76 136.89,43.76 137.52,44.39 137.52,45.79 139.59,47.86 139.59,48.81 141.35,50.57 v1(141.35,52.2)
HWPG_1.05V_EC#: length 87.5
  TOP w0.254: v1(130.78,44.32) 130.13,43.66 R1164.1 ; v1(137.31,47.54) 137.8,47.05 R1159.2 ; v1(133.83,66.94) 133.83,67.02 133.83,67.03 133.83,67.76 133.24,68.34 132.08,68.34 131.12,69.3 128.74,69.3 127.96,70.07 127.96,73.14 128,73.17 128,75.2 127.92,75.27 127.92,76.42 127.25,77.1 127.25,77.53 127.39,77.67 127.39,79.62 124.01,83 124.01,93.87 121.71,96.17 121.71,104.92 120.83,105.8 120.04,105.8 119.75,105.51 v1(118.77,105.51) 118.12,105.51 116.76,106.87 114.89,106.87 PR134.1
  IN1 w0.254: v1(133.83,66.94) 133.83,66.94 133.83,62.28 136.63,59.47 136.63,51.13 135.73,50.23 v1(135.13,50.23) 134.87,50.23 134.21,49.57 134.21,48.94 132.92,47.66 132.92,46.24 131.84,45.16 131.84,44.45 131.44,44.06 131.04,44.06 v1(130.78,44.32)
  BOTTOM w0.254: v1(135.13,50.23) 137.31,48.05 v1(137.31,47.54)
HWPG_1.35V: length 204.6
  TOP w0.254: D19.1 132.08,50.89 131.8,50.61 v1(131.8,49.88) ; PR104.1 34.75,53.95 v1(34.75,55.45)
  IN1 w0.254: v1(34.75,55.45) 34.82,55.45 36.96,53.32 36.96,47.64 35.82,46.5 35.82,45.76 35.82,45.41 35.28,44.87 35.04,44.87 33.76,43.59 33.76,36.21 37.92,32.05 40.09,32.05 41.75,30.39 77.16,30.39 77.88,31.11 92.24,31.11 93.53,32.39 96.99,32.39 97.4,32.8 97.87,32.8 98.07,32.61 105.62,32.61 107.14,34.13 111.38,34.13 114.04,36.78 116.73,36.78 117.53,37.59 121.17,37.59 121.86,38.28 123.06,38.28 124.91,40.13 124.91,43.64 126.73,45.46 126.73,45.47 127.17,45.9 129.2,45.9 131.8,48.5 v1(131.8,49.88) 131.8,50.21 132.74,51.15 135.49,51.15 135.82,51.48 135.82,57.49 v1(135.18,58.13)
  IN2 w0.254: v1(106.1,80.46) 107.35,81.71 114.25,81.71 115.08,80.88 116.81,80.88 117.16,80.53 118.97,80.53 119.83,79.68 120.19,79.68 122.07,77.8 123.67,77.8 123.93,77.54 126.43,77.54 126.74,77.86 132.37,77.86 132.69,77.54 132.69,77.04 131.6,75.94 131.6,74.14 133.09,72.65 133.09,68.4 132.48,67.79 132.48,63.67 132.76,63.39 132.76,61.96 135.18,59.54 v1(135.18,58.13)
  BOTTOM w0.254: v1(34.75,55.45) 35.38,54.82 PR110.2 ; v1(106.1,80.46) 106.1,79.99 R465.1 R452.1 104.97,80.42 105.66,81.11 Q38.6
I2C_0_SCL: length 38.7
  IN2 w0.089: 84.24,68.1 83.78,68.56 v1(82.22,68.56)
  IN2 w0.102: 84.24,68.1 91.78,68.1
  IN2 w0.14: 91.78,68.1 92.89,67 94.31,67 95.17,66.13 97.23,66.13 97.61,65.75 v1(97.61,65.73)
  BOTTOM w0.102: v1(82.22,68.56) U7.AK6 ; U19.3 111.12,56.61 111.02,56.71 109.81,56.71 108.62,57.89 108.62,62.47 106.24,64.85 103.4,64.85 103.25,64.7 102.71,64.7 101.87,63.86 100.85,63.86 100.36,64.35 99.49,64.35 99.26,64.58 98.94,64.58 R198.1 98.21,65.15 97.64,65.73 v1(97.61,65.73)
I2C_0_SCL_C: length 99.1
  TOP w0.102: v1(108.37,51.69) 108.71,52.04 R502.1
  IN2 w0.14: v1(108.37,51.69) 108.37,51.54 108.47,51.44 108.47,50.43 108.57,50.33 108.57,47.84 108.89,47.53 108.89,41.11 108.01,40.22 108.01,39.41 106.99,38.39 106.99,34.9 105.75,33.67 105.75,32.84 101.51,28.59 97.34,28.59 97.12,28.37 75.49,28.37 75.2,28.08 59.2,28.08 57.48,26.37 50.64,26.37 46.82,22.55 46.46,22.55 45.19,23.82 42.46,23.82 v1(41.8,23.16)
  BOTTOM w0.102: CN12.6 45.1,22.71 44.96,22.85 42.78,22.85 42.67,22.74 42.22,22.74 v1(41.8,23.16) ; U19.6 111.12,51.82 110.4,51.09 110,51.09 109.27,51.82 108.49,51.82 v1(108.37,51.69)
I2C_0_SDA: length 40.2
  IN2 w0.14: v1(81.51,68.56) 81.93,68.98 82.4,68.98 82.4,68.98 85.78,68.98 86.31,68.44 91.92,68.44 92.97,67.4 94.36,67.4 95.28,66.49 97.99,66.49 v1(98.96,65.52)
  BOTTOM w0.102: U7.AH7 81.28,68.87 81.36,68.76 v1(81.51,68.56) ; U19.4 111.62,56.54 111.15,57.01 109.93,57.01 108.93,58.02 108.93,62.6 106.37,65.16 103.27,65.16 103.12,65.01 102.59,65.01 101.75,64.17 100.97,64.17 100.48,64.66 100.02,64.66 R194.1 99.33,65.15 v1(98.96,65.52)
I2C_0_SDA_C: length 99.1
  TOP w0.102: R506.1 108.95,51.75 v1(108.95,51.34)
  IN2 w0.14: v1(42.5,23.16) 42.66,23.32 45.17,23.32 46.31,22.19 46.95,22.19 50.79,26.02 57.66,26.02 59.23,27.6 75.36,27.6 75.79,28.03 97.26,28.03 97.48,28.25 101.65,28.25 106.1,32.7 106.1,33.52 107.33,34.75 107.33,38.25 108.35,39.27 108.35,40.08 109.23,40.96 109.23,47.67 108.92,47.99 108.92,50.47 108.81,50.57 108.81,51.21 v1(108.95,51.34)
  BOTTOM w0.102: v1(42.5,23.16) 45.77,23.16 46.1,22.83 CN12.5 ; U19.5 111.62,51.89 110.52,50.79 109.87,50.79 109.32,51.34 v1(108.95,51.34)
I2C_1_SCL: length 21
  IN2 w0.102: v1(81.51,69.55) 81.57,69.55 82.19,70.17 84.08,70.17 84.55,69.69 85.75,69.69 85.77,69.68
  IN2 w0.14: v1(98.3,68.49) 98.3,67.91 97.61,67.22 95.43,67.22 94.49,68.16 93.85,68.16 93.45,68.57 93.45,68.67 92.51,69.61 92.08,69.61 91.55,69.08 89.18,69.08 88.58,69.68 85.77,69.68
  BOTTOM w0.102: U7.AF6 81.78,69.95 v1(81.51,69.55) ; R193.1 98.55,68.19 98.3,68.44 v1(98.3,68.49)
I2C_1_SDA: length 21.1
  IN2 w0.102: v1(82.22,69.55) 82.63,69.95 83.1,69.95 83.24,69.81 83.67,69.81
  IN2 w0.14: v1(98.96,68.39) 98.96,68.21 99.19,67.99 99.19,67.53 98.53,66.87 95.33,66.87 94.39,67.81 93.07,67.81 92.1,68.77 86.56,68.77 86.06,69.28 84.2,69.28 83.67,69.81
  BOTTOM w0.102: v1(98.96,68.39) 98.96,68.33 R189.1 ; v1(82.22,69.55) 81.99,69.23 U7.AH6
I2C_2_SCL: length 20.9
  IN2 w0.102: v1(80.09,69.55) 80.69,70.16 81.61,70.16 82.03,70.58 84.38,70.58 84.86,70.1 85.35,70.1 85.55,70.3 85.56,70.3
  IN2 w0.14: 85.56,70.3 85.57,70.31 88.94,70.31 89.53,69.72 91.22,69.72 91.79,70.29 92.8,70.29 93.64,69.45 95.13,69.45 95.77,68.81 97.5,68.81 v1(97.66,68.65)
  BOTTOM w0.102: v1(97.66,68.65) 97.66,68.34 97.6,68.27 R180.1 ; U7.AF9 80.38,69.95 80.09,69.55 v1(80.09,69.55)
I2C_2_SDA: length 19.8
  IN2 w0.102: 85.56,69.97 85.49,69.9 84.78,69.9 84.3,70.37 82.11,70.37 81.69,69.95 81.2,69.95 v1(80.8,69.55)
  IN2 w0.14: v1(97.08,68.32) 97,68.24 96.55,68.24 96.32,68.47 95.63,68.47 94.99,69.11 93.49,69.11 92.66,69.95 91.94,69.95 91.36,69.38 89.39,69.38 88.8,69.97 85.56,69.97
  BOTTOM w0.102: v1(97.08,68.32) 97.08,68.29 96.64,67.86 R186.1 ; v1(80.8,69.55) 81.09,69.95 U7.AF7
I2C_3_SCL: length 12
  BOTTOM w0.102: 86.72,71.22 85.96,71.22 85.68,70.94 84.8,70.94 84.64,70.78 84.04,70.78 83.93,70.68 83.72,70.68 83.61,70.79 83.35,70.79 83.05,70.5 U7.AE4
  BOTTOM w0.108: R171.1 93.15,70.31 v1(93.02,70.44) 92.7,70.76 90.75,70.76 90.52,70.99 90.18,70.99 89.99,70.81 89.54,70.81 89.12,71.22 86.72,71.22
I2C_3_SDA: length 9.9
  BOTTOM w0.102: U7.AD2 84.56,70.99 84.71,71.14 85.59,71.14 85.89,71.44 86.72,71.44
  BOTTOM w0.108: R158.1 92.77,70.98 90.84,70.98 90.61,71.21 89.74,71.21 v1(89.73,71.22) 89.73,71.22 89.51,71.44 86.72,71.44
I2C_4_SCL: length 5.5
  BOTTOM w0.102: 86.72,71.87 85.75,71.87 85.43,71.55 84.54,71.55 84.47,71.47 U7.AC1
  BOTTOM w0.108: 86.72,71.87 88.42,71.87 v1(88.62,72.07) 88.86,72.3 R156.1
I2C_4_SDA: length 9.4
  BOTTOM w0.102: U7.AD3 83.25,71.11 83.53,71.11 83.71,71.29 83.94,71.29 84.04,71.19 84.48,71.19 84.63,71.35 85.51,71.35 85.82,71.65 86.72,71.65
  BOTTOM w0.108: R157.1 91.2,71.38 91.14,71.44 v1(91.13,71.44) 90.91,71.65 86.72,71.65
I2C_5_SCL: length 7.9
  BOTTOM w0.102: 86.72,72.3 85.56,72.3 85.22,71.96 U7.AB2
  BOTTOM w0.108: R154.1 v1(89.99,73.34) 89.77,73.12 89.35,73.12 89.26,73.02 88.62,73.02 87.89,72.3 86.72,72.3
I2C_5_SDA: length 8.4
  BOTTOM w0.102: U7.AC3 83.66,71.67 83.95,71.67 84.04,71.75 85.33,71.75 85.66,72.08 86.72,72.08
  BOTTOM w0.108: R155.1 90.69,72.81 88.71,72.81 87.98,72.08 86.72,72.08
I2C_6_SCL: length 5.2
  BOTTOM w0.102: U7.AA1 85.13,72.44 85.42,72.73 86.72,72.73
  BOTTOM w0.108: 86.72,72.73 87.71,72.73 88.62,73.64 R1128.1
I2C_6_SDA: length 7.9
  BOTTOM w0.102: 86.72,72.52 85.49,72.52 85.14,72.16 84.04,72.16 83.94,72.26 83.7,72.26 83.4,71.96 U7.AB3
  BOTTOM w0.108: 86.72,72.52 87.8,72.52 88.53,73.24 89.17,73.24 89.87,73.94 R1129.1
I2C_NFC_SOC_SCL: length 5.1
  BOTTOM w0.102: 86.72,72.95 85.34,72.95 85.12,72.73 84.04,72.73 83.94,72.63 83.65,72.63 U7.AA3
  BOTTOM w0.108: R151.1 87.96,73.45 87.46,72.95 86.72,72.95
I2C_NFC_SOC_SDA: length 6.4
  BOTTOM w0.102: U7.Y2 85.04,72.93 85.27,73.16 86.72,73.16
  BOTTOM w0.108: 86.72,73.16 87.31,73.16 87.55,73.41 87.55,73.99 v1(87.25,74.29) 87.25,74.39 88.05,75.18 R150.1
ICLK_1P05_PWR: length 1.1
  BOTTOM w0.254: U7.V18 75.95,74.02 v1(75.57,73.64) 75.19,74.02 U7.V19
ICLK_ICOMP: length 2.4
  TOP w0.102: v1(74.33,75.34) 73.84,75.84 73.84,76.69 R369.2
  BOTTOM w0.305: v1(74.33,75.34) 74.46,75.34 U7.P20
ICLK_RCOMP: length 2.3
  TOP w0.102: R361.2 75.08,76.85 74.33,76.1 v1(74.33,76.05)
  BOTTOM w0.254: v1(74.33,76.05) 74.46,76.05 U7.N20
ICLK_VSFR_1P24_PWR: length 22.3
  TOP w0.381: C165.2 71.11,73.75 v1(71,73.65)
  TOP w0.508: R316.1 54.64,84.64 C157.1 54.73,83.54 v1(54.74,83.53)
  IN1 w0.508: v1(54.74,83.53) 55.09,83.18 57.58,83.18 58,83.59 59.96,83.59 60.25,83.3 60.25,82.92 61.27,81.91 66.7,81.91 67.59,81.02 67.59,80.08 69.34,78.32
  BOTTOM w0.254: U7.Y25 U7.Y27 71.32,73.33 71.22,73.43 v1(71,73.65)
ICMNT: length 54.2
  TOP w0.203: U9.67 141.35,26.3
  TOP w0.254: v1(104.01,23.83) 103.75,24.09 PC100.2 103.42,23.89 102.64,23.11 PR131.1 102.19,23.06 101.61,22.48 PU8.7 ; v1(135.79,25.9) 136.42,26.53 138.05,26.53 138.88,25.7 139.99,25.7 v1(140.59,26.3) 141.35,26.3
  IN1 w0.254: v1(135.79,25.9) 135.64,26.05 132.51,26.05 132.07,25.61 129.17,25.61 128.31,26.47 123.56,26.47 123.37,26.28 117.79,26.28 116.82,25.31 110.83,25.31 110.47,25.67 v1(110.36,25.67)
  BOTTOM w0.254: C121.2 146.35,27.64 144.83,26.13 140.76,26.13 v1(140.59,26.3) ; v1(110.36,25.67) 110.34,25.64 110.34,25.19 109.6,24.45 107.68,24.45 107.05,23.83 v1(104.01,23.83)
IN_CLK: length 71.5
  IN2 w0.102: v1(16.97,80.59) 16.97,80.83 17.03,80.89 17.55,80.89 18.54,81.88 18.54,84.58 17.88,85.24 17.88,91.37 21.72,95.21 26.33,95.21 29.18,92.37 35.26,92.37 37.47,94.58 42.12,94.58 43.11,95.57 46.6,95.57 48.53,93.64 50.76,93.64 52.12,92.28 52.12,91.74 53.73,90.12 55.71,90.12 56.08,89.75 56.08,88.79 56.85,88.03 56.85,84.7 v1(56.54,84.39)
  BOTTOM w0.102: 56.07,82.17 56.09,82.15 56.13,82.15 56.43,81.85 56.79,81.85 57.51,81.14 57.51,80.1 58.49,79.12 U7.G53
  BOTTOM w0.114: 56.07,82.17 56.01,82.23 56.01,83.15 56.9,84.04 56.9,84.3 56.8,84.39 v1(56.54,84.39) ; C6.1 16.26,80.95 16.84,80.95 16.97,80.83 v1(16.97,80.59)
IN_CLK#: length 71.5
  IN2 w0.102: v1(57.34,84.39) 57.05,84.69 57.05,88.11 56.29,88.87 56.29,89.84 55.8,90.33 53.82,90.33 52.33,91.82 52.33,92.36 50.84,93.84 48.62,93.84 46.69,95.77 43.03,95.77 42.04,94.78 37.39,94.78 35.18,92.57 29.26,92.57 26.42,95.42 21.64,95.42 17.68,91.46 17.68,85.16 18.34,84.5 18.34,81.96 17.47,81.09 17.25,81.09 v1(16.97,81.37)
  BOTTOM w0.102: U7.G52 59.06,79.45 58.44,79.45 57.71,80.19 57.71,81.22 56.87,82.06 56.52,82.06 56.28,82.3 56.28,82.34 56.27,82.34 56.27,82.38
  BOTTOM w0.114: v1(57.34,84.39) 57.17,84.22 57.17,83.93 56.27,83.04 56.27,82.38 ; v1(16.97,81.37) 16.82,81.22 16.52,81.22 C7.1
