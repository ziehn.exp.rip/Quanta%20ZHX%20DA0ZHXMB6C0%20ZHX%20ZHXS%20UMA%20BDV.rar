# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_VCORE: length 40.4
  TOP w0.254: PC129.2 40.63,58.41 v1(40.05,59) ; PR150.2 PR149.2 44.6,83.66 v1(44.5,83.76)
  IN1 w0.254: v1(40.05,59) 40.62,59.56 40.62,61.68 41.62,62.68 42.09,62.68 42.25,62.52 42.94,62.52 43.1,62.68 44.15,62.68 44.57,63.1 44.57,63.87 46.88,66.19 46.88,68.14 47.64,68.9 47.64,71.79 47.93,72.08 47.93,76.67 47.65,76.95 47.65,81.67 45.57,83.76 v1(44.5,83.76)
  BOTTOM w0.203: PU4.5 40.49,62.7
  BOTTOM w0.254: 40.49,62.7 40.49,62.45 40.67,62.27 40.67,59.59 40.08,59 v1(40.05,59)
GND_VGG: length 30.3
  TOP w0.203: PU6.5 123.14,49.59 122.98,49.43 122.98,46.6 PC162.2
  TOP w0.254: PR210.2 111.4,60.68 PR211.2 111.39,60.44 111.62,60.21 v1(111.89,60.21) ; v1(121.38,46.05) PC162.2
  IN1 w0.254: v1(121.38,46.05) 121.02,46.41 115.46,46.41 113.79,48.07 113.79,50.77 113.26,51.3 113.26,54.27 113.92,54.93 114.54,55.55 114.54,57.76 112.09,60.21 v1(111.89,60.21)
PVCC_VCORE: length 5.7
  TOP w0.508: v1(39.85,70.73) 39.84,70.73 PR170.2
  BOTTOM w0.203: 40.62,69.69 40.99,69.32 40.99,68.33 40.89,68.24 PU4.21
  BOTTOM w0.508: 40.62,69.69 40.44,69.87 39.46,69.87 PC141.2 39.39,70.26 v1(39.85,70.73)
VCC0_SENSEN_R: length 40.8
  IN2 w0.102: 57.28,73.04 57.43,73.19 58.28,73.19 58.81,72.66 60.13,72.66 60.33,72.86 61.5,72.86 62.06,72.3 65.21,72.3 65.41,72.1 67.11,72.1 67.79,71.43 67.79,69.56 68.26,69.09 68.6,69.09 v1(68.77,68.92)
  IN2 w0.254: 57.28,73.04 55.3,73.04 54.79,73.55 53.42,73.55 52.96,74.01 51.75,74.01 51.16,73.42 48.53,73.42 47.61,74.34 47.61,81.45 45.62,83.45 45.62,84.34 45.04,84.93 v1(44.45,84.93)
  BOTTOM w0.102: v1(68.77,68.92) 69.13,68.56 U7.AJ32
  BOTTOM w0.254: v1(44.45,84.93) 44.63,84.93 45.18,85.48 T1.1 44.57,86.81 R141.2
VCC0_SENSEP_R: length 41
  IN2 w0.102: v1(69.5,68.93) 69.1,69.33 68.31,69.33 67.99,69.64 67.99,71.51 67.19,72.3 65.5,72.3 65.3,72.5 62.15,72.5 61.55,73.1 60.17,73.1 59.95,72.88 58.95,72.88 58.39,73.44 57.22,73.44
  IN2 w0.254: 57.22,73.44 57.19,73.41 55.67,73.41 55.06,74.01 53.59,74.01 53.14,74.46 51.43,74.46 51.02,74.06 48.79,74.06 48.25,74.6 48.25,81.71 46.36,83.61 46.36,84.52 45.31,85.56 v1(44.3,85.56)
  BOTTOM w0.102: v1(69.5,68.93) 69.13,69.3 U7.AG32
  BOTTOM w0.254: v1(44.3,85.56) 43.97,85.89 R146.2 43.49,85.86 T4.1
VCC1_SENSEN: length 3.9
  TOP w0.254: PR150.1 46.11,85.32 v1(46.31,85.51)
  BOTTOM w0.254: R137.1 45.35,88.12 R141.1 46.31,86.06 v1(46.31,85.51)
VCC1_SENSEN_R: length 40.7
  IN2 w0.102: v1(71.78,70.51) 70.85,71.44 68.83,71.44 66.73,73.55 66.73,73.83 66.17,74.39 61.45,74.39 61.12,74.72
  IN2 w0.254: 61.12,74.72 61.05,74.79 59.72,74.79 58.67,75.83 54.33,75.83 53.7,76.47 53.7,77.75 52.93,78.51 52.93,81.28 51.81,82.4 51.81,84.97 49.33,87.45 48.82,87.96 44.18,87.96 v1(43.84,88.31)
  BOTTOM w0.102: U7.AF27 71.4,70.13 v1(71.78,70.51)
  BOTTOM w0.254: R137.2 44.02,88.12 v1(43.84,88.31)
VCC1_SENSEP: length 2.7
  TOP w0.254: PR148.1 42.16,84.86 v1(42.57,85.28)
  BOTTOM w0.254: R144.1 42.72,85.91 R146.1 42.57,85.72 v1(42.57,85.28)
VCC1_SENSEP_R: length 39.9
  IN2 w0.102: 60.67,74.27 61.28,74.27 61.39,74.16 66.11,74.16 66.52,73.74 66.52,73.46 68.75,71.24 70.54,71.24 71.02,70.75 v1(71.02,70.5)
  IN2 w0.254: 60.67,74.27 59.32,74.27 58.22,75.38 54.05,75.38 53.06,76.37 53.06,77.49 52.3,78.25 52.3,81.02 51.55,81.77 51.18,82.14 51.18,84.71 48.56,87.33 43.84,87.33 v1(43.5,87.67)
  BOTTOM w0.102: U7.AD29 71.02,70.51 v1(71.02,70.5)
  BOTTOM w0.254: R144.2 v1(43.5,87.67)
VCC_VCORE: length 5.2
  TOP w0.508: PR166.2 40.11,61.56 v1(39.65,62.02) 39.65,62.87 PR55.1
  BOTTOM w0.203: PU4.6 40.09,62.31
  BOTTOM w0.254: PC50.2 40.16,61.42 40.16,62.22 40.09,62.29 40.09,62.31
  BOTTOM w0.508: v1(39.65,62.02) 39.65,61.58 PC50.2
VCCRTC_1: length 3.1
  TOP w0.508: R479.1 142.57,103.22 142.88,103.52 v1(143.03,103.52) 143.67,103.52 143.82,103.37 145.06,103.37 D17.1
VCCRTC_2: length 2.9
  TOP w0.508: R411.2 140.47,98.48 139.47,99.48 v1(139.47,99.51) 139.47,99.76 139.7,99.99 139.7,100.68
VCCRTC_3: length 1.5
  TOP w0.508: R411.1 v1(139.69,97.58) R410.2
VCCSRANSOCI_OBS: length 1.5
  TOP w0.381: R386.2 70.14,72.73 69.52,72.11 v1(69.52,72.08)
  BOTTOM w0.254: U7.AA30 69.88,72.44 v1(69.52,72.08)
VDDI_DSC: length 3.7
  TOP w0.108: C315.2 115.82,80.44 v1(115.9,80.36)
  BOTTOM w0.064: 115.99,79.24 115.99,79 116,78.99 116,78.76 115.89,78.66 115,78.66 U20.C2
  BOTTOM w0.108: v1(115.9,80.36) 115.99,80.27 115.99,79.24
670AGND: length 3.3
  BOTTOM w0.203: PU3.14 132.04,95.89
  BOTTOM w0.254: PC51.1 130.56,96.25 PR43.2 130.79,96.48 131.45,96.48 132.04,95.89
671AGND: length 11.1
  IN1 w0.254: v1(136.37,109.21) 133.71,109.21 132.94,109.97 132.94,110.86 v1(133.15,111.06)
  BOTTOM w0.203: v1(136.37,109.21) 136.75,108.84 PR66.2 136.36,108.26 135.25,108.26 134.96,107.98 PU5.14
  BOTTOM w0.254: PR71.2 134.22,109.41 133.27,109.41 PC69.1 132.94,109.73 132.94,110.86 v1(133.15,111.06)
5041_VCC: length 2.7
  TOP w0.508: PR9.2 v1(117.02,101.87)
  BOTTOM w0.203: PU1.11 116.89,101.74 v1(117.02,101.87)
  BOTTOM w0.508: v1(117.02,101.87) 117.1,101.87 117.4,101.56 PC18.1
24707_LX: length 2
  TOP w0.635: PR86.1 90.44,23.75 v2(90.62,23.56) 91.02,23.16 PC96.1
  vias: v1(92.58,22.14)
24737_ACDET: length 7.3
  TOP w0.254: PU8.6 101.25,21.98 101.54,21.69 PR122.2 102.11,21.81 v1(102.71,22.41)
  BOTTOM w0.254: PR119.2 99.92,20.78 v1(101.65,22.52) 102.6,22.52 v1(102.71,22.41)
24737_ACN: length 153.2
  TOP w0.254: PC109.1 96.27,18.54 v1(96.27,18.89) 97.16,19.78 PC104.2 97.32,20.07 98.06,20.81 PU8.1
  IN1 w0.254: v1(22.45,85.59) 22.99,85.05 22.99,81.63 23.74,80.88 23.74,74.11 25.23,72.62 25.23,65.44 23.75,63.96 23.75,55.67 26.04,53.38 27.08,53.38 28.37,52.09 29.82,52.09 30.78,51.13 32.68,51.13 33.09,50.73 33.09,49.48 32.69,49.09 32.4,49.09 31.5,48.18 31.5,47.13 30.01,45.65 30.01,34.93 33.53,31.42 33.53,30.75 35.04,29.24 35.7,29.24 36.72,28.23 38.51,28.23 39.17,27.57 39.17,26.66 39.89,25.93 42.72,25.93 43.78,24.87 47.16,24.87 47.52,24.5 48.94,24.5 50.48,26.05 78.49,26.05 80.22,27.78 93.57,27.78 94.13,27.22 96.24,27.22 97.18,26.28 98.3,26.28 99.77,24.81 100.41,24.81 100.85,24.37 100.85,24.37 100.92,24.3 100.92,21.93 99.28,20.29 97.67,20.29 v1(96.27,18.89)
  BOTTOM w0.254: v1(22.45,85.59) 22.56,85.69 23.21,85.69 PR140.1
24737_ACP: length 152.5
  TOP w0.254: PU8.2 98.56,19.82 PC104.1 98.52,19.49 v1(97.92,18.89) 98.52,18.29 PC108.2
  IN1 w0.254: v1(22.78,86.2) 23.5,85.49 23.5,81.84 24.27,81.06 24.27,74.29 25.74,72.83 25.74,65.23 24.26,63.75 24.26,55.88 26.25,53.89 27.29,53.89 28.58,52.59 30.03,52.59 30.99,51.64 32.89,51.64 33.59,50.94 33.59,49.26 32.92,48.58 32.61,48.58 32.01,47.97 32.01,46.87 31.72,46.58 30.52,45.39 30.52,35.14 34.04,31.63 34.04,30.98 35.26,29.75 35.92,29.75 36.85,28.81 38.64,28.81 39.73,27.73 39.73,26.81 40.1,26.44 42.94,26.44 43.99,25.38 47.54,25.38 47.91,25.01 48.72,25.01 50.27,26.55 78.28,26.55 80.01,28.29 93.8,28.29 94.36,27.73 96.57,27.73 97.51,26.79 98.51,26.79 99.98,25.32 100.62,25.32 101.43,24.51 101.43,21.72 99.49,19.78 98.81,19.78 v1(97.92,18.89)
  BOTTOM w0.254: v1(22.78,86.2) 23.61,87.03 PR135.1
24737_BM#: length 7.9
  TOP w0.254: PU8.11 100.06,25.2 100.92,26.05 v1(101.27,26.05)
  BOTTOM w0.254: PR91.1 v1(97.56,28.3) 97.74,28.3 98.57,27.46 PQ11.2 101.27,26.39 v1(101.27,26.05)
24737_BST:
  vias: v1(96.17,23.38)
24737_CMPIN: length 8.2
  TOP w0.254: PR131.2 103.42,22.42 v1(103.4,22.4) ; PU8.4 99.56,20.68 PR130.1 100.24,20.04 100.96,20.76 v1(101.37,20.76) 101.72,20.41 101.72,20.16 PR124.2
  BOTTOM w0.254: v1(103.4,22.4) 102.88,21.87 102.88,20.95 102.21,20.28 v1(102.01,20.28) 101.85,20.28 v1(101.37,20.76)
24737_CMPOUT: length 16
  TOP w0.254: v1(105.65,24.64) 105.65,24.64 105.65,25.45 PR123.1 104.73,26.37 104.73,26.59 PR129.1 104.73,26.96 105,27.23 PQ12.2 ; PU8.3 99.06,20.68 99.73,20.02 99.73,19.48 99.94,19.26 PR130.2 100.25,19.26 100.84,19.85 v1(100.84,19.93)
  IN2 w0.254: v1(100.84,19.93) 100.46,20.31 100.46,20.89 101.11,21.55 102.86,21.55 103.16,21.85 103.97,21.85 104.31,22.2 104.31,23.35 105.4,24.44 105.45,24.44 105.65,24.64 v1(105.65,24.64)
24737_DH:
  vias: v1(95.45,22.32) v2(94.75,22.38)
24737_DL:
  vias: v1(96.85,24.7) v2(95.07,24.65)
24737_ILIM: length 11.5
  TOP w0.127: v1(101.33,25.36) 101.33,24.14 101.17,23.98 PU8.10
  BOTTOM w0.127: PR92.1 96.77,29.3 PC93.2 PR102.2 98.83,29.29 PR105.2 98.83,28.39 99.04,28.18 100.94,28.18 101.96,27.17 101.96,25.8 101.52,25.36 v1(101.33,25.36)
24737_REGN:
  vias: v1(92.91,27.55)
24737_SRN: length 15.9
  TOP w0.254: PR100.1 100.38,26.13 v1(100.23,26.13)
  BOTTOM w0.254: PC80.1 99.49,25.97 99.65,26.13 v1(100.23,26.13) ; PC80.1 99.47,25.97 99.16,26.27 99.16,26.28 98.86,26.58 v1(97.95,26.58) 96.79,27.74 94.84,27.74 94.33,28.26 88.09,28.26 PR97.2 ; PC80.1 99.47,25.49 99.52,25.44 PC79.2
24737_SRP: length 14.1
  TOP w0.254: v1(97.69,25.7) 97.69,26.25 PR101.1
  BOTTOM w0.254: PC80.2 98.69,25.16 PC78.2 98.28,25.32 98.28,25.4 97.98,25.7 v1(97.69,25.7) 97.71,25.8 97.71,26.1 v1(96.55,27.26) 94.61,27.26 94.12,27.75 88.09,27.75 PR96.2
24737_VCC: length 12.6
  TOP w0.279: 96.9,21.25 97.11,21.45 97.11,21.75 PU8.20
  TOP w0.508: PR126.2 90.36,20.94 95.21,20.94 95.72,20.42 PC103.2 96.9,20.95 96.9,21.25
51216DRVH: length 13.3
  IN1 w0.762: 21.64,43.75 21.64,46 25.29,49.65 26.85,49.65 28.17,50.97 v2(29.47,50.97)
  BOTTOM w0.203: v2(29.47,50.97) 29.93,50.5 PU7.14
  vias: v1(21.48,43.01) v1(21.48,42.35)
51216DRVL: length 3.7
  IN1 w0.762: v2(30.48,48.75) 29.51,48.75 28.2,47.44 v2(28.2,47.08)
  BOTTOM w0.203: PU7.11 v2(30.48,48.75)
51216MODE: length 2.9
  BOTTOM w0.203: 32.38,52.04 PU7.19
  BOTTOM w0.254: 32.38,52.04 32.66,52.31 33.4,52.31 34.24,53.15 PR112.2
51216PG: length 3.4
  BOTTOM w0.102: 33.58,52.07 33.54,52.03 32.92,52.03 32.78,51.9 PU7.20
  BOTTOM w0.127: PR110.1 34.9,52.67 34.18,52.67 33.58,52.07
51216REFIN: length 4.1
  BOTTOM w0.203: 31.98,47.97 PU7.8
  BOTTOM w0.254: 31.98,47.97 31.27,47.26 PC97.1 PR116.1 32.39,47.07 PR111.2
51216S3: length 3.6
  TOP w0.254: PC101.1 31.88,52.85 v1(31.58,52.55)
  BOTTOM w0.203: PU7.17 31.58,52.14
  BOTTOM w0.254: 31.58,52.14 v1(31.58,52.55) 31.37,52.76 PR237.1 31.39,53.15 PR118.1
51216S5: length 2.7
  TOP w0.254: v1(30.84,52.54) 30.74,52.64 PC102.1
  BOTTOM w0.203: PU7.16 31.18,52.19
  BOTTOM w0.254: PR121.1 30.33,53.04 v1(30.84,52.54) 31.18,52.19
51216SW: length 9.7
  IN2 w0.762: v2(29.34,49.9) 28.75,49.9 26.54,47.7 26.54,46.04 v2(28.01,44.57)
  BOTTOM w0.203: v2(29.34,49.9) 29.54,50.1 PU7.13
  BOTTOM w0.508: v2(29.34,49.9) 28.77,49.34 PC105.2
  vias: v1(28.02,45.3)
51216TRIP: length 2.4
  BOTTOM w0.203: 31.98,52.14 PU7.18
  BOTTOM w0.254: PR115.2 32.98,52.67 32.51,52.67 31.98,52.14
+CLKDDR_1P35_PWR: length 6.5
  TOP w0.508: C264.1 72.89,67.13 72.54,66.78 v1(72.54,66.59) 72.39,66.44 C269.1
  BOTTOM w0.254: U7.AM25 72.16,66.97 v1(72.54,66.59)
  BOTTOM w0.508: v1(72.62,51.45) 72.71,51.36 C271.1 72.71,50.32 73.36,49.67 73.36,48.14 R437.1
+G_SEN_PW: length 29.3
  TOP w0.203: v1(119.03,27.42) 119.03,27.24 120.05,26.22 R486.2 v1(119.03,26) 118,24.98 U21.8 ; C321.1 109.74,25.97 109.65,26.05 v1(109.65,26.46) ; C321.1 109.55,25.55 109.55,24.65 109.22,24.32 109.22,23.34 C314.1 110.42,22.15 113.44,22.15 113.68,22.39 U21.1 ; C321.1 109.91,25.57 109.91,25.31 110.24,24.98 U21.14
  IN1 w0.203: v1(119.03,27.42) 118.82,27.22 117.55,27.22 116.59,26.25 111.89,26.25 111.18,26.97 110.16,26.97 v1(109.65,26.46)
+LCDVCC:
  vias: v1(67.29,93.01)
+PLLDDR_1P35_PWR: length 6.3
  TOP w0.508: C268.1 71.02,66.32 v1(71.02,66.58) 71.11,66.67 C263.1
  BOTTOM w0.254: v1(71.02,66.58) 71.26,66.33 71.27,66.32 71.27,66.32 U7.AN27
  BOTTOM w0.381: v1(70.93,49.81) 72,49.81 72.57,49.23 C273.1 72.57,48.61 71.49,47.53 R436.1
+TPVDD_1: length 87.8
  TOP w0.508: v1(108.2,46.55) 108,46.55 107.57,46.98 107.57,47.87 108.54,48.83 108.54,50.52 107.72,51.33 107.72,52.52 108.51,53.31 R502.2 R506.2 R496.1
  IN2 w0.508: 46.71,24.93 46.71,26.08 47.58,26.94 57.24,26.94 58.97,28.67 74.68,28.67 74.96,28.95 96.88,28.95 97.1,29.17 101.27,29.17 105.18,33.08 105.18,33.9 105.83,34.56 105.83,39.12 106.29,39.58 106.29,40.46 108.31,42.49 108.31,45.78 108.2,45.9 v1(108.2,46.55)
  vias: v1(51.82,23.46) v2(46.74,24.12) v2(46.69,23.31)
+V_SMDDR_VREF_DIMM: length 104.9
  TOP w0.254: v1(105.35,43.84) 105.72,43.47 C766.1 106.05,43.48 C47.1 ; C735.1 71.12,45.2 C734.1 70.87,45.45 70.07,45.45 69.91,45.61 v1(69.72,45.61) ; v1(39.91,44.79) C732.1 C733.1
  TOP w0.33: U27.M8 v1(101.8,42.97) ; v3(84.01,43.01) 83.65,43.37 U26.M8
  TOP w0.356: U25.M8 v1(66.75,42.97) ; U24.M8 v3(48.96,42.97)
  IN1 w0.203: 47.07,44.07 46.57,43.57 45.63,43.57 45.5,43.7 44.87,43.7 ; v1(78.42,42.97) 79.54,42.97 80.13,43.55 80.74,43.55 80.92,43.37 81.47,43.37 81.81,43.03 83.99,43.03 v3(84.01,43.01) 84.01,40.41 ; v1(101.8,42.97) 101.65,43.11 99.96,43.11 99.9,43.17 99.45,43.62 98.9,43.62 98.67,43.4 98.36,43.4 97.92,42.97 v1(96.2,42.97) 95.74,42.51 95.74,38.76 92.53,35.55 89.66,35.55
  IN1 w0.254: v1(101.8,42.97) 101.8,43.28 102.51,43.99 105.2,43.99 v1(105.35,43.84) ; v3(48.96,42.97) 47.86,44.07 47.07,44.07 ; 84.01,40.41 84.01,39.58 88.04,35.55 89.66,35.55 ; 44.87,43.7 44.13,42.97 v1(43.37,42.97)
  IN2 w0.203: v3(48.96,42.97) 49.4,42.54 50.93,42.54 51.13,42.74 52.52,42.74 52.95,43.17 54.11,43.17 54.55,43.6 56,43.6 56.43,43.17 56.86,43.17 57.28,42.75 58.28,42.75 58.83,42.2 60.18,42.2 60.43,42.45 60.63,42.45 v3(61.14,42.97) 61.2,42.92 63.04,42.92 63.09,42.96 63.59,42.96 63.64,42.92 64.03,42.92 64.23,43.12 65.19,43.12 65.34,42.97 65.53,42.97
  IN2 w0.254: v1(39.91,44.79) 40.67,44.03 42.5,44.03 43.37,43.16 v1(43.37,42.97) ; 65.53,42.97 v1(66.75,42.97) 66.75,43.95 68.4,45.61 v1(69.72,45.61) 69.72,46.05 70.37,46.7 73.67,46.7 74.13,46.24 75.06,46.24 76.68,44.62 v1(76.68,43.82) 76.87,43.63 77.75,43.63 v1(78.42,42.97)
  BOTTOM w0.254: U32.M8 61.54,43.37 v3(61.14,42.97) ; v1(39.91,44.79) v1(38.18,44.79) 37.67,44.79 R1040.2 R1041.1 C719.2 ; C765.1 105.79,43.4 v1(105.35,43.84) ; C764.1 74.75,43.17 75.4,43.82 v1(76.68,43.82) ; U34.M8 v1(78.42,42.97)
  BOTTOM w0.33: U31.M8 43.76,43.37 v1(43.37,42.97) ; U33.M8 v1(96.2,42.97)
+V_SMDDR_VREF_DQ0: length 56.1
  TOP w0.254: v1(39.24,45.7) 39.24,46.51 C745.1 C727.2 R1044.1 R1042.2 ; v1(59.88,46.5) 59.95,46.57 60.74,46.57 U25.H1 ; U24.H1 42.96,46.57 42.15,46.57 v3(42.11,46.6) ; C748.1 71.05,46.68 69.09,46.68 68.8,46.39 v1(68.8,46.39)
  IN1 w0.203: v1(68.8,46.39) 68.41,46 68.29,46 65.45,43.16 64.44,43.16 64.21,42.92 62.77,42.92 60.52,45.18 60.52,45.86 v1(59.88,46.5)
  IN1 w0.254: v3(42.11,46.6) 41.21,45.7 v1(39.24,45.7)
  IN2 w0.102: 44.82,45.83 44.57,46.09 44.57,46.32 44.32,46.57 43.73,46.57 43.77,46.53 43.77,46.04 44.06,45.75 44.44,45.75 44.47,45.72 44.71,45.72 44.82,45.83
  IN2 w0.178: 45.7,46.26 46.16,46.26 46.5,46.26 46.51,46.26 46.59,46.26 46.81,46.04 46.81,45.93 47.18,45.56
  IN2 w0.203: 47.18,45.56 47.68,45.56 48.01,45.89 50.02,45.89 v3(50.05,45.86) 50.4,45.86 52.35,47.81 55.73,47.81 55.79,47.75 57.08,47.75 57.39,47.43 58.18,47.43 59.04,46.57 59.81,46.57 v1(59.88,46.5) ; 44.82,45.83 44.87,45.79 45.23,45.79 45.7,46.26 ; v3(42.11,46.6) 43.15,46.6 43.19,46.64 43.66,46.64 43.73,46.57
  BOTTOM w0.254: v3(50.05,45.86) 51.86,45.86 C746.1 ; C747.1 70.11,44.06 69.68,44.49 69.41,44.76 69.41,45.2 68.8,45.81 68.8,46.39 v1(68.8,46.39) 68.8,46.39 68.28,46.39 68.2,46.47 67.6,46.47 67.51,46.57 67.15,46.57 U32.H1
  BOTTOM w0.305: U31.H1 49.37,46.55 v3(50.05,45.86)
+V_SMDDR_VREF_DQ1: length 52.7
  TOP w0.254: C775.1 105.97,45.23 105.43,45.23 105.42,45.24 105.37,45.24 v1(105.37,45.24) ; U27.H1 95.72,46.49 95.72,46.46 95.45,46.19 95.07,46.19 94.81,46.46 94.81,46.52 v1(94.65,46.67) ; C774.1 77.31,46.68 v1(77.43,46.57) 77.43,46.57 78.02,46.57 U26.H1
  IN2 w0.178: 95.9,45.78 96.41,45.78 ; 99.06,45.8 99.48,46.23
  IN2 w0.203: v3(102.63,46.14) 102.24,45.75 102.24,45.2 101.95,44.92 100.83,44.92 100.51,45.24 100.51,45.84 100.12,46.23 99.48,46.23 ; 95.9,45.78 95.49,46.19 95.11,46.19 94.86,46.44 94.86,46.45 94.65,46.65 v1(94.65,46.67) 94.43,46.45 90.37,46.45 89.52,47.3 87.83,47.3 87.34,46.81 87.05,46.81 86.99,46.87 86.53,46.87 86.53,46.87 86.28,46.62 86.28,46.62 86.17,46.52 86.17,46.08 v3(86.18,46.08) 85.97,45.87 82.67,45.87 82.45,46.09 81.8,46.09 81.58,46.31 80.82,46.31 79.39,44.89 78.24,44.89 77.43,45.71 v1(77.43,46.57) ; 96.41,45.78 96.53,45.9 98.56,45.9 98.66,45.8 99.06,45.8
  IN2 w0.254: v1(105.37,45.24) 103.53,45.24 v3(102.63,46.14)
  BOTTOM w0.254: v3(86.18,46.08) 85.69,46.57 U34.H1 ; v1(94.65,46.67) 94.18,46.2 C773.1 ; C776.1 106.06,45.24 v1(105.37,45.24) 105.37,45.24 105.37,44.51 105.73,44.15 v1(107.31,44.15) C795.2 R1107.1 108.33,43.41 R1108.2 ; U33.H1 102.21,46.57 v3(102.63,46.14)
+VGG:
  vias: v1(73.3,69.72) v1(74.05,69.72) v1(74.81,69.72) v1(75.57,70.5) v1(75.57,69.72) v1(76.33,70.47) v1(76.33,69.72) v1(95.35,70.53) v2(110.41,66.56) v2(110.47,65.81) v2(111.03,65.24) v2(111.11,66.27) v2(111.62,65.72) v2(111.91,66.67) v2(112.7,66.69) v2(114.05,63.34) v2(114.05,62.58) v2(114.81,63.34) v2(114.81,62.58) v2(114.81,61.81) v2(115.57,63.34) v2(115.57,62.58) v2(115.57,61.81) v2(115.83,64.99) v2(116.33,64.1) v2(116.33,63.34) v2(116.59,64.99) v2(117.6,64.99) v2(118.37,64.99) v2(119.13,64.99)
+VREF_VCORE: length 36.5
  TOP w0.254: v1(42.64,63.04) 42.64,63.04 42.44,63.24 41.84,63.24 PR54.2
  IN1 w0.254: v1(41.48,83.43) 41.81,83.1 45.51,83.1 47.14,81.46 47.14,76.74 47.4,76.49 47.4,73.55 46.71,72.86 45.9,72.86 45.44,72.41 45.44,71.8 45.85,71.39 45.85,67.37 45.01,66.54 44.27,66.54 43.37,65.64 43.37,64.9 42.22,63.74 42.22,63.31 42.49,63.04 v1(42.64,63.04)
  BOTTOM w0.203: PU4.1 42.09,62.91 42.23,62.77 42.38,62.77 v1(42.64,63.04)
  BOTTOM w0.254: v1(41.48,83.43) 41.48,83.52 PR26.2 ; v1(42.64,63.04) 42.85,63.04 v1(43.17,62.72) 43.59,62.3 PC40.1 44.1,61.32 44.1,60.26 PR161.2
+VREF_VGG: length 19.5
  TOP w0.203: PC159.1 v1(119.57,49.21) 119.86,49.21 120.65,50 121.32,50 121.54,50.22 PU6.1
  IN1 w0.254: v1(119.1,56.3) 117.13,56.3 115.78,54.95 115.78,52.18 116.5,51.46 117.36,51.46 117.43,51.53 117.91,51.53 118.54,50.89 118.54,49.88 119.21,49.21 v1(119.57,49.21)
  BOTTOM w0.254: PR81.2 PC159.1 v1(119.57,49.21) ; PR28.2 120.07,57.6 120.07,56.84 119.53,56.3 v1(119.1,56.3)
+VRTC_3P3: length 7.2
  TOP w0.508: v1(81.47,81.26) 82.14,81.93 C159.1 82.49,82.12 83.3,82.93 C150.1 83.3,84.48 83.34,84.52 83.34,85.7 R318.2
  BOTTOM w0.305: U7.B6 81.47,81.35 v1(81.47,81.26) 81.87,81.26 U7.C5
AC_PRESENT: length 14.9
  BOTTOM w0.102: U7.C13 78.39,81.75 78.39,82.05 78.69,82.35 78.69,83.35 79.12,83.78 ; 80.17,84.91 80.17,85.81 80.58,86.22 R1011.2 80.58,87.06
  BOTTOM w0.108: 80.58,87.06 R33.2 80.28,87.48 79.76,88 79.76,88.76 79.31,89.21 79.31,90.58 80.27,91.53 81.2,91.53 v1(81.87,92.19) 82.14,91.91 82.93,91.91 ; 79.12,83.78 80.17,84.83 80.17,84.91
AC_PROTECT: length 29
  TOP w0.203: U9.4 127.73,36.7 v1(127.8,36.63)
  TOP w0.254: v1(109.75,28.51) 109.75,28.21 109.4,27.85 106.77,27.85 PR129.2
  IN1 w0.254: v1(127.8,36.63) 126.52,35.35 124.58,35.35 124.17,35.76 121.12,35.76 119.76,34.4 117.47,34.4 115.82,32.75 115.01,32.75 114.58,32.32 114.58,31.33 113.86,30.62 111.45,30.62 109.75,28.92 v1(109.75,28.51)
ACCEL_INTA: length 108
  TOP w0.108: v1(90.86,82.08) 91.4,82.62 R489.2 90.48,82.71 90.07,82.3 Q43.1 90.07,80.75 R504.1
  TOP w0.203: U21.11 114.68,29.04 C326.2 114.42,29.3 113.79,29.3 v1(113.72,29.38)
  IN1 w0.14: v1(125.33,70.93) 123.18,70.93 122.45,71.66 119.59,71.66 118.96,71.02 112.31,71.02 108.99,74.34 108.99,75.38 107.85,76.52 103.5,76.52 102.69,75.71 99.88,75.71 95.68,79.91 94.29,79.91 93.6,80.61 91.65,80.61 90.86,81.4 v1(90.86,82.08)
  IN2 w0.203: v1(113.72,29.38) 113.67,29.38 113.3,29.75 111.49,29.75 110.05,31.19 110.05,32.76 112.25,34.97 112.25,37.89 113.47,39.11 113.47,43.44 113.29,43.62 113.29,44.09 113.49,44.29 113.49,46.66 114.18,47.35 114.18,48.87 113.69,49.36 113.69,52.95 113.42,53.22 113.42,53.96 112.37,55.01 111.94,55.01 111.12,55.82 111.12,56.5 111.82,57.2 112.27,57.2 112.5,57.43 112.5,61.08 111.94,61.64 111.94,64.12 116.61,68.8 120.49,68.8 120.77,69.08 121.82,69.08 122.01,69.27 123.78,69.27 125.33,70.82 v1(125.33,70.93)
ACIN: length 57.4
  TOP w0.127: PQ36.3 96.45,30.53 96.29,30.36 95.7,30.36 PR228.1 95.37,30.45 v1(95.37,29.94) ; U9.72 141.61,28.3 141.24,27.93 140.21,27.93 139.73,27.44 v1(139.73,26.23)
  IN1 w0.127: v1(139.73,26.23) 139.29,26.23 136.57,23.51 128.71,23.51 127.56,24.65 124.32,24.65 124.12,24.46 118.54,24.46 117.33,23.25 115.68,23.25 114.98,22.55 107.9,22.55 107.01,23.44 107.01,23.95 104.78,26.18 104.78,27.21 102.51,29.48 95.59,29.48 95.37,29.7 95.37,29.93 v1(95.37,29.94)
ACPRESENT: length 130.4
  TOP w0.127: v1(131.52,55.46) 131.52,54.5 131.07,54.05 131.07,51.97 129.33,50.23 128.86,50.23 127.2,48.56 127.2,45.56 126.01,44.38 119.05,44.38 116.04,41.36 114.88,41.36 114.02,40.5 114.02,39.64 112.72,38.35 112.01,38.35 111.74,38.08 111.74,37.76 110.98,37.01 110.37,37.01 110.12,36.76 110.12,35.66 109.42,34.97 105.72,34.97 103.79,34.97 102.78,33.96 101.69,33.96 PR222.1 100.4,31.11 PR220.1
  IN2 w0.127: v1(89.49,90.08) 91.4,88.17 93.61,88.17 94.73,87.05 95.21,87.05 95.73,86.52 96.36,86.52 98.04,84.84 99.16,84.84 99.72,84.27 100.47,84.27 100.74,84 101.54,84 102.06,83.47 102.89,83.47 103.39,82.97 104.26,82.97 104.76,83.47 114.33,83.47 115.62,82.18 116.9,82.18 117.57,81.52 119.38,81.52 120.24,80.67 120.81,80.67 122.69,78.79 126.75,78.79 127.34,78.19 132.51,78.19 133.02,77.67 133.02,76.9 132.7,76.58 132.7,73.64 133.42,72.93 133.42,68.26 132.81,67.65 132.81,66 134.01,64.81 134.01,61.32 135.64,59.69 135.64,57.72 134.98,57.06 133.12,57.06 v1(131.52,55.46)
  BOTTOM w0.127: v1(89.49,90.08) 89.49,91.71 88.41,92.78 88.41,94.62 Q21.2
ACZ_BCLK: length 19.6
  IN2 w0.14: v1(80.76,71.45) 81.95,72.63 83.67,72.63 84.05,72.25 86.49,72.25 86.72,72.02 88.49,72.02 88.56,72.09 90.98,72.09 91.05,72.02 93.49,72.02 94.23,71.29 95.94,71.29 v1(96.01,71.36)
  BOTTOM w0.102: v1(96.01,71.36) 96.01,70.96 96.24,70.73 97.02,70.73 R202.1 ; U7.AD9 v1(80.76,71.45)
ACZ_RST#: length 20.9
  IN2 w0.102: 82,71.01 81.88,71.01 81.44,70.56 79.62,70.56 v1(78.56,69.51)
  IN2 w0.14: 82,71.01 84.01,71.01 84.44,71.44 85.93,71.44 86.33,71.04 90.54,71.04 90.63,70.95 93.07,70.95 93.91,70.11 95.41,70.11 95.68,69.84 v1(96.55,69.84)
  BOTTOM w0.102: U7.AF13 78.31,69.77 v1(78.56,69.51) ; v1(96.55,69.84) 96.47,69.84 96.26,69.62 R206.1
ACZ_RST#_AUDIO: length 28.4
  TOP w0.508: v1(31.57,29.66) 31.45,29.78 28.5,29.78 27.96,29.24 27.96,24.87 27.56,24.47 27.55,24.47 Q11.1 ; v1(14.98,28.82) R124.1
  IN1 w0.508: v1(14.98,28.82) 15.52,28.82 16.64,29.94 17.8,29.94 19.09,31.23 22.45,31.23 23.01,30.67 29.41,30.67 30.43,29.66 v1(31.57,29.66)
ACZ_RST#_AUDIO_R: length 6
  TOP w0.108: D10.1 24.77,22.06 25.39,21.44 25.9,21.44 v1(26.16,21.17) 26.8,20.54 R252.1 27.04,20.78 28.07,21.81 Q11.3
ACZ_SDIN: length 5.1
  TOP w0.102: U4.8 12.31,18.4 12.98,19.06 15.02,19.06 v1(15.52,19.57) 15.55,19.6 R63.1
ACZ_SDOUT: length 22.9
  IN2 w0.102: v1(77.9,69.56) 79.11,70.77 81.35,70.77 82.02,71.44
  IN2 w0.14: 82.02,71.44 82.29,71.7 82.48,71.9 83.09,71.9 83.3,71.68 86.03,71.68 86.4,71.31 90.65,71.31 90.74,71.22 93.18,71.22 94.02,70.38 95.52,70.38 95.57,70.32 96.72,70.32 v1(97.21,69.84)
  BOTTOM w0.102: v1(77.9,69.56) 77.6,69.87 U7.AF14 ; R208.1 97.79,70.42 v1(97.21,69.84)
ACZ_SPKR: length 231.8
  TOP w0.102: D8.2 19.81,36.47 19.63,36.29 v1(19.38,36.29)
  IN1 w0.14: v1(110.9,73.57) 110.9,72.81 112.42,71.29 118.85,71.29 119.48,71.92 122.56,71.92 122.97,71.51 124.73,71.51 125.54,72.32 128.82,72.32 129.63,71.51 130.36,71.51 130.9,70.97 130.9,70.27 131.64,69.53 132.24,69.53 133.67,68.1 134.31,68.1 134.78,67.63 134.78,66.99 134.25,66.47 134.25,62.66 137.14,59.78 137.14,55.33 138.93,53.54 138.93,51.1 134.54,46.72 134.54,45.52 134.13,45.11 134.13,44.21 131.51,41.59 131.51,41.06 131.24,40.79 130.68,40.79 130.46,41.01 130.46,41.3 v1(130,41.76)
  IN2 w0.14: v1(19.38,36.29) 19.69,35.98 19.69,34.04 19.69,33.71 22.26,31.14 30.03,31.14 30.36,31.47 32.7,31.47 33.08,31.85 36.58,31.85 41.04,27.39 53.77,27.39 56.18,29.81 75.48,29.81 75.88,29.4 96.65,29.4 96.86,29.62 101.08,29.62 104.73,33.26 104.73,34.09 105.38,34.75 105.38,40.19 107.86,42.67 107.86,45.6 v1(107.37,46.09)
  BOTTOM w0.102: v1(107.37,46.09) 107.37,47.67 108.44,48.75 111.07,48.75 111.41,48.41 113.84,48.41 117.19,45.06 117.19,44.47 117.6,44.06 118.13,44.06 118.6,43.59 123.65,43.59 123.97,43.27 128.49,43.27 v1(129.31,42.45) v1(130,41.76) ; v1(110.9,73.57) 110.65,73.83 106.58,73.83 104.9,75.5 103.94,75.5 102.41,77.03 101.92,77.03 100.31,78.64 99.39,78.64 99.36,78.66 98.55,79.47 98.18,79.47 96.92,80.73 89.11,80.73 86.99,78.6 84.79,78.6 84.75,78.65 83.9,78.65 83.4,78.56 83.21,78.56 82.96,78.81 U7.H4
ACZ_SYNC: length 22.2
  IN2 w0.102: 85.48,71.2 84.51,71.2 84.1,70.79 81.95,70.79 81.52,70.36 80.05,70.36 v1(79.22,69.54)
  IN2 w0.14: v1(98.15,69.18) 98.12,69.18 98.02,69.28 95.86,69.28 95.3,69.85 93.8,69.85 92.96,70.68 91.63,70.68 91.06,70.11 89.7,70.11 89.1,70.7 85.98,70.7 85.48,71.2
  BOTTOM w0.102: R203.1 98.2,69.23 v1(98.15,69.18) ; v1(79.22,69.54) 79.22,69.82 U7.AF12
ADOGND: length 16.9
  TOP w0.203: U4.38 6.79,14.16 6.29,13.66 6.29,13.3 v1(6.14,13.14)
  TOP w0.254: v1(7.31,30.97) 7.31,30.39 7.17,30.26 Q6.1 ; v1(9.62,28.71) 9.37,28.96 Q6.4
  TOP w0.381: v1(9.4,35.98) 9.02,35.98 8.81,35.77 R321.2
  TOP w0.457: C22.2 17.26,50.17 v1(17.45,49.98) ; C26.2 v1(6.53,23.17) ; C65.2 v1(5.26,11.74) C69.2 ; C62.1 v1(3.04,11.56) ; v1(17.6,41.98) 17.77,41.81 R339.1 ; C60.1 3.04,12.69 v1(3.04,12.69) ; v1(9.4,32.22) 9.64,32.47 C23.1
  TOP w0.508: 5.9,11.1 C69.2 ; C880.2 6.61,9.56 v1(6.22,9.95) ; v1(14.85,48.81) 15.19,48.47 D27.2
  BOTTOM w0.381: C27.2 16.25,39.83 16.34,39.92 v1(16.34,40.05)
  BOTTOM w0.457: v1(17.6,41.98) 17.77,41.81 R327.1
  BOTTOM w0.508: v1(7.14,35.86) 7.38,36.09 D28.2 ; v1(17.45,49.98) 17.54,49.89 C24.2
  vias: v1(1.1,34.1) v1(1.1,30.41) v1(1.1,25.5) v1(1.1,21.82) v1(1.1,18.14) v1(1.1,14.46) v1(1.09,12.07) v1(1.98,9.97) v1(2.29,23.19) v1(2.29,22.18) v1(2.29,21.16) v1(2.29,20.14) v1(2.29,19.13) v1(2.29,18.11) v1(5.33,20.51) v1(9.17,24.92) v1(13.22,45.13) v1(13.19,41.52) v1(13.74,47.01) v1(13.67,39.72)
ALERT#: length 3.2
  BOTTOM w0.108: U8.6 107.42,66.87 107.57,67.02 107.57,68.54 TP10.1
ALERT#_VCORE: length 4.9
  BOTTOM w0.108: PR171.2 35.2,67.44 35.67,67.91 36.33,67.91 PR36.2 36.81,67.37 38.06,66.12 PU4.14
ALERT#_VGG: length 5
  TOP w0.203: PU6.14 125.89,53.27 PR73.2 127.52,53.83 128.82,53.83 128.99,53.65 PR197.2
AMP_MUTE#: length 156.1
  TOP w0.108: U9.108 136.3,38.69 136.43,38.56 136.43,38.14 136.73,37.84 138.18,37.84 140.95,35.07 v1(140.95,34.28) ; v1(23.12,26.2) 23.37,26.2 23.72,25.85 v1(23.72,25.09) 23.72,24.62 22.99,23.88 D9.1
  IN1 w0.14: v1(143.54,31.74) 143.91,31.74 144.32,31.34 144.32,30.9 145.29,29.93 145.29,25.62 141.38,21.71 138.42,21.71 138.08,22.05 128.1,22.05 126.96,23.2 124.92,23.2 124.05,22.33 121.44,22.33 120.74,21.63 103.22,21.63 99.84,18.26 77.14,18.26 74.78,20.61 74.78,21.89 72.1,24.58 58.1,24.58 57.34,25.34 50.77,25.34 48.12,22.69 41.62,22.69 41.1,23.21 41.1,24.37 40.59,24.88 33.17,24.88 32.67,24.37 25.4,24.37 23.57,26.2 v1(23.12,26.2)
  BOTTOM w0.108: v1(140.95,34.28) 143.48,31.74 v1(143.54,31.74)
BAT-V: length 11.7
  BOTTOM w0.152: PR113.2 80.41,27.65 80.51,27.75 80.51,29.79 81.05,30.32 84.16,30.32 84.46,30.02 84.46,28.28 84.61,28.13 86.8,28.13 PR97.1
  vias: v1(61.91,25.53) v1(62.57,25.53) v1(63.23,25.53) v1(63.89,25.53) v1(64.55,25.53) v1(65.21,25.53) v1(65.87,25.53) v1(75.97,27.19) v1(76.71,27.22) v1(77.42,27.22) v1(78.18,27.22) v2(63.34,21.54) v2(63.34,20.77) v2(64.1,21.54) v2(64.1,20.77) v2(64.86,21.54) v2(64.86,20.77) v2(65.62,21.54) v2(65.62,20.77) v2(77.87,18.91) v2(78.63,18.91) v2(79.39,18.91)
BATLED0#: length 144.4
  TOP w0.108: v1(126.27,22.18) v1(126.27,24.04) 127.56,25.33 127.56,26.59 127.45,26.7 U9.29 ; R266.2 v1(7.06,4.7)
  IN1 w0.14: v1(126.27,22.18) 126.27,21.81 125.25,20.79 103.57,20.79 100.19,17.42 76.79,17.42 70.47,23.74 57.76,23.74 57.02,24.48 51.09,24.48 48.47,21.85 40,21.85 38.47,23.38 37.11,23.38 35.31,21.59 33.03,21.59 32,20.56 21.33,20.56 17.91,17.14 17.91,13.1 15.9,11.09 10.96,11.09 10.3,10.44 10.3,8.79 7.04,5.53 7.04,4.72 v1(7.06,4.7)
BATLED1#: length 149.2
  TOP w0.108: U9.25 127.47,28.3 127.78,27.99 127.78,25.24 126.92,24.39 v1(126.92,22.82) v1(126.92,22.18) ; R267.2 6.29,2.84 6.27,2.84 v1(6.25,2.81)
  IN1 w0.14: v1(126.92,22.18) 126.46,22.64 125.15,22.64 124.28,21.77 121.67,21.77 120.97,21.07 103.45,21.07 100.08,17.7 76.91,17.7 70.59,24.02 57.87,24.02 57.13,24.76 50.98,24.76 48.35,22.13 40.12,22.13 38.53,23.71 37.03,23.71 35.19,21.87 32.75,21.87 31.72,20.84 21.2,20.84 17.63,17.26 17.63,13.25 15.75,11.37 10.84,11.37 10.02,10.55 10.02,8.97 6.25,5.2 v1(6.25,2.81)
BATT_EN#: length 103.3
  TOP w0.127: v1(67.74,19.88) 67.74,19.68 PR224.2 ; v1(143.68,27.42) 144.02,27.42 144.69,26.75 R1171.1 145.92,26.75 146.94,25.74 147.31,25.74 148.8,24.25 v1(149.86,24.25)
  IN1 w0.127: v1(143.68,27.42) 143.68,24.77 142.2,23.29 137.65,23.29 136.95,22.59 128.33,22.59 127.18,23.74 124.7,23.74 124.42,23.46 122.95,23.46 122.16,22.67 119.43,22.67 119.08,22.32 v1(119.08,22.14)
  BOTTOM w0.127: v1(119.08,22.14) 119.03,22.09 117.47,22.09 116.11,20.73 103.64,20.73 99.96,17.05 84.9,17.05 83.95,18 69.62,18 v1(67.74,19.88) 67.33,20.3 PJ2.6 ; v1(149.86,24.25) SW3.4 SW3.3
BATT_EN#_R: length 11.4
  TOP w0.127: v1(148.97,25.11) 148.59,25.11 147.07,26.63 Q12.3 145.81,27.52 R1171.2
  BOTTOM w0.127: SW3.1 SW3.2 151,27.65 148.97,25.62 v1(148.97,25.11)
BEEP_1: length 3.2
  TOP w0.102: C34.2 v1(13.66,22.22) C30.1 R32.2 R25.1
BI_GATE: length 39.5
  TOP w0.254: v1(149.98,36.64) 149.61,37 Q13.5 ; R998.2 150.62,27.52 C125.1 150.53,27.47 v1(149.96,27.47) 149.1,26.61 Q12.2
  IN2 w0.254: v1(149.98,36.64) 149.98,38.46 149.23,39.21 146.81,39.21 145.15,37.54 139.05,37.54 137.34,35.83 v1(137.34,35.4)
  BOTTOM w0.254: SW2.1 139.15,30.91 139.46,31.22 139.46,32.15 138.94,32.67 138.94,35.69 SW2.3 138.47,35.9 137.97,35.4 v1(137.34,35.4) ; v1(149.98,36.64) 150.22,36.39 150.22,36.02 149.12,34.93 149.12,28.31 v1(149.96,27.47)
BIOS_STRAP: length 14.6
  TOP w0.108: R201.2 90.46,68.95 89.49,68.95 89.22,69.21 89.22,69.52 88.72,70.02 87.38,70.02 86.74,69.38 v1(86.74,69) 85.85,68.11 83.74,68.11 82.77,69.08 80.2,69.08 R200.1 79.77,68.95 v1(79.37,68.56)
  BOTTOM w0.102: U7.AK10 v1(79.37,68.56)
BL#: length 5.5
  BOTTOM w0.108: R306.2 R310.2 v1(42.29,27.9) 42.67,27.9 42.93,28.16 Q5.3 43.82,27.52 Q3.2
BLON_CON: length 157.3
  IN1 w0.14: v1(38.35,26.92) 37.75,27.52 35.56,27.52 34.66,28.43 34.15,28.43 32.84,29.73 32.84,30.44 32.82,30.46 32.82,31.13 32.1,31.85 31.38,31.85 31.17,32.07 29.16,32.07 27.66,33.57 22.02,33.57 21.09,34.51 21.09,41.22 19.94,42.36 19.94,43.27 19.46,43.75 19.46,51.02 19.26,51.22 19.24,51.22 17.97,52.49 17.97,54.84 18.39,55.26 19.94,55.26 20.5,55.82 20.5,56.58 18.19,58.9 18.19,60.77 18.98,61.57 21.17,61.57 21.87,62.27 21.87,64.6 23.45,66.18 23.45,71.87 20.77,74.54 20.77,76.44 21.58,77.26 21.58,79.42 20.88,80.12 20.88,80.56 19.03,82.41 19.03,86.73 21.49,89.2 21.49,92.09 24.99,95.6 28.23,95.6 30.29,93.53 34.99,93.53 38.2,96.75 46.18,96.75 47.34,97.9 53.08,97.9 55.53,100.36 61.43,100.36 61.75,100.04 v1(61.75,100.04)
  BOTTOM w0.108: Q3.3 40.64,25.87 Q24.3 37.36,27.19 36.88,27.68 D15.2 37.72,28.54 37.97,28.79 R301.1 R293.2 v1(38.35,26.92) ; CN10.15 68.25,96.38 68.54,96.67 68.54,97.52 68.01,98.05 67.15,98.05 65.08,100.12 65.08,100.98 64.75,101.31 64.39,101.31 62.6,99.52 62.02,99.52 61.75,99.79 v1(61.75,100.04)
BMPD_1P05_PWR: length 4
  BOTTOM w0.254: U7.U24 72.92,74.92 v1(73.38,75.39) 73.67,75.09 U7.U22 ; U7.V24 73.05,74.16 73.55,74.16 U7.V22 74.05,74.42 v1(74.05,74.45) ; U7.U27 71.78,74.43 v1(71.78,74.42) U7.V27
  vias: v1(72.29,76.75)
BOARD_ID0: length 7.5
  BOTTOM w0.102: U7.A9 80.24,82.5 80.29,82.55 80.29,83.11 80.69,83.51 80.69,83.69 81.39,84.38 82.87,84.38 83.11,84.63 ; R1027.1 83.69,87 R1026.2
  BOTTOM w0.108: 83.11,84.63 83.19,84.7 83.19,85.84 83.69,86.35 R1027.1
BOARD_ID1: length 10.9
  BOTTOM w0.102: R308.2 84.49,87.36 84.84,87.36 ; 83.27,84.25 83.2,84.18 81.47,84.18 80.89,83.61 80.89,83.43 80.49,83.03 80.49,82.56 80.57,82.49 80.57,82.18 80.32,81.93 80.32,81.75 U7.C9 ; 85.32,86.96 R55.1
  BOTTOM w0.108: 83.27,84.25 83.46,84.44 84.3,84.44 85.22,85.36 85.22,85.88 R55.1 ; 84.84,87.36 R34.2 85.36,86.99 85.32,86.96
BOARD_ID2: length 10.1
  BOTTOM w0.102: U7.B8 80.66,81.98 80.77,82.09 80.77,82.57 80.7,82.65 80.7,82.94 81.1,83.34 81.1,83.52 81.55,83.98 83.33,83.98 83.59,84.23 84.47,84.23 84.55,84.32
  BOTTOM w0.108: 84.55,84.32 85.45,85.21 85.45,86.17 v1(85.57,86.3) 85.64,86.37 R54.1 R40.2
BOARD_ID3: length 11
  BOTTOM w0.102: 83.42,83.77 81.64,83.77 81.4,83.54 81.4,83.2 81.58,83.02 81.58,82.52 81.49,82.43 81.49,81.97 U7.B7
  BOTTOM w0.108: R37.2 87.4,86.37 R53.1 86.95,85.92 86.95,84.54 86.51,84.11 84.64,84.11 84.55,84.03 83.67,84.03 83.42,83.77
BOARD_ID4: length 11.5
  BOTTOM w0.102: U7.B5 82.24,81.92 82.24,82.45 82.2,82.49 82.2,83.28 82.49,83.57 83.52,83.57 83.77,83.82 84.64,83.82 84.71,83.9 86.34,83.9
  BOTTOM w0.108: R36.2 88.42,86.92 88.38,86.88 R52.1 88.82,85.93 88.82,85.36 88.63,85.17 88.07,85.17 87.84,84.94 87.84,84.68 87.06,83.9 86.34,83.9
BOARD_ID5: length 10.6
  BOTTOM w0.102: U7.B4 83.03,81.98 82.96,82.05 82.96,82.73 83.85,83.62 84.72,83.62 84.78,83.68 85.87,83.68
  BOTTOM w0.108: 85.87,83.68 87.15,83.68 88.06,84.59 88.06,84.86 88.16,84.95 88.72,84.95 89.03,85.27 89.03,85.95 R51.1 89.45,86.83 89.43,86.84 R35.2
BOOT_VCORE: length 3.1
  BOTTOM w0.203: 41.29,69.76 PU4.22
  BOTTOM w0.508: PR31.2 41.29,70.29 41.29,69.76
BOOT_VGG: length 3.2
  TOP w0.203: PR56.2 122.19,56.9 v1(122.23,56.86) 122.28,56.81 122.28,56.51 122.15,56.38 122.15,55.55 122.34,55.36 PU6.22
BRIGHT: length 3.4
  TOP w0.108: v1(66.6,94.38) 66.42,94.55 R382.1
  BOTTOM w0.108: CN10.14 67.75,94.41 67.51,94.17 66.8,94.17 v1(66.6,94.38)
BRTC_EXTPAD: length 4.5
  TOP w0.102: C142.1 77.46,83.38 77.6,83.24 v1(77.6,83.25)
  IN2 w0.102: v1(77.6,83.25) 77.6,83.24 77.75,83.09 77.75,80.84 v1(77.23,80.32)
  BOTTOM w0.102: v1(77.23,80.32) U7.F16
BT_EN_R: length 4.8
  TOP w0.076: CN5.54 159.59,98.5
  TOP w0.108: R821.1 156.36,98.97 156.84,98.5 v1(156.9,98.5) 159.59,98.5
BT_POWERON: length 87.8
  TOP w0.108: v1(147.83,31.46) 147.83,31.57 147.28,32.12 144.93,32.12 144.54,31.72 144.19,31.72 143.61,32.3 U9.82 ; v1(151.08,97.2) 151.59,97.2 v1(152.5,98.11) 152.78,98.39 153.79,98.39 C694.2 154.28,97.95 R821.2
  IN1 w0.14: v1(151.08,97.2) 151.08,97.12 147.93,93.97 147.93,82.79 147.48,82.33 147.48,80.1 147.69,79.88 147.69,78.03 148.34,77.38 148.34,76.68 148.7,76.32 152.68,76.32 154.9,74.1 154.9,68.96 154.25,68.31 154.25,57.69 154.9,57.05 154.9,41.48 153.2,39.78 153.2,39.2 149.31,35.31 149.31,34.79 148.97,34.44 148.97,32.32 148.11,31.46 v1(147.83,31.46)
C_TX0_HDMI+: length 14.5
  TOP w0.114: R271.2 13.79,76.94 13.09,76.94 v1(12.78,76.63) 12.52,76.89 12.28,76.89 12.09,76.7 12.09,74.7 11.47,74.07 9.99,74.07 9.42,74.63 9.42,77.79 9.29,77.92 9.2,77.92 CN2.7
  BOTTOM w0.114: v1(12.78,76.63) 13.11,76.97 13.89,76.97 R5.1 14.33,76.99 14.88,76.99 C10.2
C_TX0_HDMI-: length 14.6
  TOP w0.114: CN2.9 9.09,78.19 9.4,78.19 9.69,77.9 9.69,74.74 10.1,74.34 11.35,74.34 11.82,74.81 11.82,76.81 12.17,77.16 12.5,77.16 v1(12.78,77.43) 13,77.21 13.64,77.21 R270.2
  BOTTOM w0.114: v1(12.78,77.43) 12.98,77.23 13.79,77.23 R5.2 14.38,77.26 14.83,77.26 C11.2
C_TX1_HDMI+: length 9.4
  TOP w0.114: v1(12.75,78.77) 13.03,79.05 13.72,79.05 R277.2
  BOTTOM w0.114: CN2.4 10.69,76.41 11.52,76.41 11.94,76.83 11.94,78.61 12.34,79.01 12.51,79.01 v1(12.75,78.77) 13.03,79.05 13.84,79.05 R2.1 14.34,79.04 14.87,79.04 C4.2
C_TX1_HDMI-: length 9.4
  TOP w0.114: R276.2 13.71,79.31 13.01,79.31 v1(12.75,79.57)
  BOTTOM w0.114: C5.2 14.84,79.3 14.37,79.3 R2.2 13.84,79.31 13.01,79.31 v1(12.75,79.57) 12.46,79.28 12.23,79.28 11.67,78.72 11.67,76.94 11.41,76.67 10.61,76.67 CN2.6
C_TX2_HDMI+: length 9.9
  TOP w0.114: R273.2 13.71,74.99 13.28,74.99 v1(12.78,74.49)
  BOTTOM w0.114: CN2.1 9.14,74.86 9.33,74.86 9.45,74.74 9.45,74.35 9.93,73.87 11.49,73.87 12.35,74.73 12.53,74.73 v1(12.78,74.49) 13.17,74.88 13.95,74.88 R4.1 14.37,75 14.85,75 C8.2
C_TX2_HDMI-: length 9.7
  TOP w0.114: R272.2 13.72,75.25 12.81,75.25 v1(12.78,75.29)
  BOTTOM w0.114: C9.2 14.87,75.26 14.34,75.26 R4.2 13.74,75.15 12.92,75.15 v1(12.78,75.29) 12.48,75 12.24,75 11.38,74.13 10.04,74.13 9.71,74.46 9.71,74.85 9.44,75.12 9.16,75.12 CN2.3
C_TXC_HDMI+: length 8.6
  TOP w0.114: v1(12.62,80.79) 12.87,81.04 13.76,81.04 R275.2
  BOTTOM w0.114: C6.2 14.86,81.08 14.35,81.08 R3.1 13.84,81.08 12.92,81.08 v1(12.62,80.79) 12.41,81.01 12.27,81.01 12.12,80.86 12.12,79.9 11.58,79.37 10.65,79.37 CN2.10
C_TXC_HDMI-: length 8.7
  TOP w0.114: R274.2 13.67,81.3 12.91,81.3 v1(12.62,81.59)
  BOTTOM w0.114: CN2.12 10.65,79.63 11.47,79.63 11.85,80.01 11.85,80.97 12.15,81.27 12.31,81.27 v1(12.62,81.59) 12.87,81.35 13.84,81.35 R3.2 14.36,81.35 14.86,81.35 C7.2
CARD_3V3: length 17.4
  IN1 w0.508: v1(19.99,25.52) 19.99,25.62 20.98,26.61 22.25,26.61 24.16,28.52 26.72,28.52 26.73,28.51 28.12,28.51 v1(28.58,28.97)
  BOTTOM w0.254: v1(27.66,29.23) 27.58,29.15 27.56,29.15 27.04,28.63 U23.5
  BOTTOM w0.508: CN16.6 17.78,22.63 18.61,23.46 C420.2 18.98,24.23 C419.1 19.4,24.93 v1(19.99,25.52) ; v1(28.58,28.97) 28.13,28.97 27.88,29.23 v1(27.66,29.23)
CCD_PWR:
  vias: v1(65.43,97.25) v1(65.69,100.07) v1(66.08,97.27)
CF1_3P3_PWR: length 7.8
  BOTTOM w0.508: U7.G1 85,79.18 85.14,79.04 86.84,79.04 87.38,79.57 C167.1 87.53,79.78 88.64,80.88 R328.2 R329.2 R1031.2
CF3_3P3_PWR: length 2.4
  BOTTOM w0.254: 85.19,81.05 84.59,81.05 U7.E1 83.75,80.67 U7.E2
  BOTTOM w0.508: 85.19,81.05 85.49,80.75 v1(85.49,80.58)
CLK_24M_DEBUG: length 61.7
  TOP w0.102: v1(135.47,75.81) 136.13,75.14 136.31,75.14 136.47,74.99 137.18,74.99 137.55,75.36 R332.1
  BOTTOM w0.102: R120.1 94.98,78.06 95.21,77.83 v1(95.4,77.83) 95.79,77.83 96.98,76.63 96.98,76.5 101.03,72.46 104.11,72.46 105.41,71.16 108.59,71.16 110.29,69.46 114.41,69.46 114.76,69.1 118.46,69.1 120.51,67.06 121.73,67.06 122.36,67.69 125.35,67.69 126.15,66.89 130.47,66.89 130.67,67.09 132.49,67.09 133.78,68.38 135.9,68.38 136.36,68.84 136.36,69.64 135.31,70.68 134.37,70.68 134.15,70.91 134.15,72 135.93,73.78 135.93,73.83 136.31,74.21 136.31,74.96 v1(135.47,75.81)
CLK_24M_DEBUG_C: length 45.2
  TOP w0.102: R332.2 136.59,75.4 v1(136.11,75.88)
  IN2 w0.14: v1(154.05,92.57) 153.77,92.29 152.6,92.29 152.3,92.6 149.3,92.6 148.81,92.1 148.81,85.47 148.03,84.7 148.03,81.14 148.87,80.31 148.87,75.17 146.37,72.67 143.69,72.67 141.11,75.25 140.8,75.25 138.83,77.22 137.26,77.22 136.11,76.07 v1(136.11,75.88)
  BOTTOM w0.102: v1(154.05,92.57) 155.73,94.25 CN5.71
CLK_24M_KBC: length 105.5
  TOP w0.102: U9.13 127.49,33.1 128.04,33.65 128.04,33.79 127.81,34.02 127.81,34.16 127.96,34.31 128.1,34.31 128.33,34.08 128.47,34.08 128.61,34.23 128.61,34.37 128.39,34.6 128.39,34.74 128.53,34.88 128.67,34.88 128.9,34.66 129.04,34.66 129.24,34.85 129.24,37.61 v1(129.58,37.95)
  IN2 w0.14: v1(129.58,37.95) 129.64,38.02 129.64,39.2 128.07,40.78 128.07,41.91 127.87,42.11 126.74,42.11 125.83,43.02 125.83,48.67 128.42,51.27 130.98,51.27 131.3,51.59 131.9,51.59 134.94,54.63 135.86,54.63 137.98,56.75 137.98,61.26 137.47,61.77 137.47,63.82 137.61,63.96 138.31,63.96 138.45,64.1 138.45,64.38 138.31,64.52 137.61,64.52 137.47,64.65 137.47,64.93 137.61,65.07 138.31,65.07 138.45,65.21 138.45,65.49 138.31,65.63 137.61,65.63 137.47,65.77 137.47,66.05 137.61,66.19 138.31,66.19 138.45,66.33 138.45,66.61 138.31,66.75 137.61,66.75 137.47,66.89 137.47,68.13 136.22,69.38 v1(135.87,69.38)
  BOTTOM w0.102: v1(135.87,69.38) 135.87,69.08 135.66,68.86 133.58,68.86 132.29,67.57 130.47,67.57 130.27,67.37 126.35,67.37 125.55,68.17 122.78,68.17 121.83,69.12 119.81,69.12 118.51,70.42 110.69,70.42 108.99,72.12 105.81,72.12 104.51,73.42 102.2,73.42 97.85,77.77 97.34,77.77 96.09,79.03 v1(95.93,79.03) R112.1 ; v1(129.58,37.95) 128.61,36.99 R249.2
CLK_PCIE_WLANN: length 109.5
  IN2 w0.14: v1(76.1,84.37) 76.1,84.54 76.35,84.79 76.8,84.79 78.83,86.82 81.4,86.82 83.11,88.53 83.11,88.79 83.59,89.27 85.62,89.27 85.91,89.56 87.29,89.56 88.71,90.98 89.45,90.98 91.75,88.69 93.93,88.69 95.06,87.56 96.05,87.56 98.26,85.35 99.37,85.35 99.93,84.79 100.68,84.79 100.96,84.51 101.75,84.51 102.28,83.99 115.02,83.99 116.3,82.71 117.11,82.71 117.78,82.04 119.61,82.04 120.46,81.18 121.02,81.18 122.9,79.3 126.96,79.3 127.56,78.7 132.5,78.7 133.6,79.8 141.05,79.8 142.12,80.87 143.35,80.87 v1(143.62,80.6)
  BOTTOM w0.102: v1(143.62,80.6) 143.92,80.9 144.85,80.9 147.82,83.87 147.82,92.51 150.15,94.83 152.99,94.83 153.95,95.79 153.95,95.84 155.65,97.54 155.65,98.7 156.93,99.98 157.13,99.98 157.36,99.75 CN5.49 ; v1(76.1,84.37) 76.1,84.68 76.01,84.78 75.78,84.78 75.54,84.54 75.54,83.56 75.97,83.13 75.97,82.15 76.15,81.98 76.15,81.87 75.99,81.71 75.9,81.71 75.77,81.83 U7.B18
CLK_PCIE_WLANP: length 109.5
  IN2 w0.14: v1(76.1,85.18) 76.22,85.05 76.69,85.05 78.72,87.09 81.28,87.09 82.84,88.65 82.84,88.9 83.48,89.54 85.51,89.54 85.8,89.82 87.18,89.82 88.6,91.25 89.56,91.25 91.86,88.95 94.04,88.95 95.17,87.83 96.16,87.83 98.37,85.62 99.48,85.62 100.05,85.05 100.79,85.05 101.07,84.78 101.86,84.78 102.39,84.25 115.13,84.25 116.41,82.97 117.22,82.97 117.89,82.3 119.72,82.3 120.57,81.45 121.13,81.45 123.01,79.57 127.07,79.57 127.67,78.97 132.39,78.97 133.49,80.07 140.94,80.07 142.01,81.14 143.35,81.14 v1(143.62,81.41)
  BOTTOM w0.102: U7.C18 75.77,81.52 75.48,81.81 75.48,82.05 75.77,82.34 75.77,83.05 75.34,83.48 75.34,84.62 75.7,84.98 75.9,84.98 v1(76.1,85.18) ; CN5.47 157.33,100.25 157.27,100.18 156.85,100.18 155.45,98.78 155.45,97.63 153.75,95.93 153.75,95.88 152.91,95.04 150.07,95.04 147.62,92.59 147.62,83.96 144.77,81.1 143.92,81.1 v1(143.62,81.41)
CLK_TPM: length 52.9
  IN2 w0.14: v1(126.26,71.77) 126.26,70.97 123.96,68.67 122.28,68.67 v1(121.92,68.32)
  BOTTOM w0.102: R121.1 95.89,78.54 97.46,76.97 97.46,76.71 97.62,76.55 97.76,76.55 97.99,76.78 98.14,76.78 98.28,76.64 98.28,76.5 98.05,76.26 98.05,76.12 98.19,75.97 98.33,75.97 98.57,76.21 98.71,76.21 98.86,76.06 98.86,75.92 98.62,75.69 98.62,75.54 98.77,75.4 98.91,75.4 99.14,75.63 99.29,75.63 99.43,75.49 99.43,75.35 99.2,75.11 99.2,74.97 99.34,74.82 99.48,74.82 99.72,75.06 99.86,75.06 100.01,74.91 100.01,74.77 99.77,74.54 99.77,74.39 99.92,74.25 100.06,74.25 100.29,74.48 100.44,74.48 100.58,74.34 100.58,74.2 100.35,73.96 100.35,73.82 100.49,73.67 100.63,73.67 100.87,73.91 101.01,73.91 101.16,73.76 101.16,73.62 100.92,73.39 100.92,73.24 101.06,73.1 101.18,73.1 101.44,73.37 101.57,73.37 102,72.94 104.31,72.94 105.61,71.64 108.79,71.64 110.49,69.94 118.31,69.94 120.37,67.88 121.49,67.88 v1(121.92,68.32) ; v1(126.26,71.77) 125.78,71.29 125.53,71.29 125.4,71.41 125.4,71.62 125.75,71.97 125.75,72.97 125.88,73.1 126.09,73.1 126.22,72.96 126.22,72.36 126.32,72.26 126.53,72.26 126.63,72.36 126.63,72.62 126.73,72.72 128.39,72.72 C240.1 129.24,72.92 U13.21
CLKRUN#: length 129.4
  TOP w0.102: v1(149.12,41.39) 148.4,40.67 148.4,35.31 147.8,34.71 147.36,34.71 146.7,35.37 R233.2
  IN2 w0.14: v1(124.61,66.89) 125.27,67.55 127.48,67.55 128.23,68.3 v1(128.23,68.63) ; v1(134.84,74.23) 135.34,73.72 135.34,73.03 136.08,72.29 136.08,70.26 137.99,68.35 137.99,67.89 139.2,66.68 139.2,63.75 139.72,63.23 139.72,62.78 138.5,61.56 138.5,56.54 136.07,54.11 135.15,54.11 132.12,51.07 131.52,51.07 131.19,50.75 128.64,50.75 126.35,48.45 126.35,43.24 126.95,42.63 128.39,42.63 129.53,41.49 129.53,40.79 130.08,40.24 134.27,40.24 134.99,39.52 140.71,39.52 141.49,40.3 143.93,40.3 145.63,42 148.51,42 v1(149.12,41.39)
  BOTTOM w0.102: v1(128.23,68.63) 129,68.63 R415.1 129.07,68.7 130.05,68.7 130.21,68.53 131.65,68.53 131.87,68.75 131.87,69.07 133.66,70.86 133.66,73.05 v1(134.84,74.23) ; v1(124.61,66.89) 124.16,66.44 120.45,66.44 118.26,68.62 114.56,68.62 114.21,68.98 110.09,68.98 108.39,70.68 105.21,70.68 103.91,71.97 100.83,71.97 96.53,76.27 96.53,76.33 95.53,77.33 94.84,77.33 94.6,77.58 91.5,77.58 R126.1
CLKRUN#R: length 3.9
  TOP w0.108: U9.93 143.12,36.7 143.26,36.57 143.26,36.05 143.48,35.82 v1(144.27,35.82) 144.96,35.82 R233.1
COMP_VCORE: length 3.8
  TOP w0.254: PR163.2 43.53,61.48 v1(42.95,61.48)
  BOTTOM w0.203: PU4.2 41.69,62.85 41.91,62.63
  BOTTOM w0.254: 41.91,62.63 42.31,62.22 PC43.1 42.94,61.48 v1(42.95,61.48)
COMP_VGG: length 3.8
  TOP w0.203: PR212.2 120.52,49.22 v1(120.73,49.42) 120.73,49.42 121.01,49.7 121.6,49.7 121.94,50.03 PU6.2
  BOTTOM w0.254: PC83.1 120.52,49.21 v1(120.73,49.42)
CORE_1P05_PWR:
  vias: v1(65.08,87.77) v1(65.05,87.11) v1(65.51,86.63) v1(67.99,74.42) v1(67.99,73.64) v1(68.74,73.64) v1(68.75,72.85) v1(68.75,72.1) v1(69.5,72.89)
CORE_1P8_PWR: length 16.7
  TOP w0.508: R402.2 92.85,67 93.23,67.38 R398.2 93.42,68.01 v1(93.42,69.41) 91.62,71.21 89.85,71.21 89.3,70.65 87.07,70.65 85.7,69.28 C228.1 83.2,69.28 v1(82.93,69.55)
  BOTTOM w0.254: U7.AH4 82.68,69.23 82.7,69.26 v1(82.93,69.55) 82.59,69.86 82.42,70.03 82.4,70.03 U7.AF4
CORE_PWROK: length 39.5
  TOP w0.108: C173.1 77.78,81.4 77.78,80 77.38,79.61 v1(77.23,79.61) ; v1(104.17,73.85) 104.17,74.28 R178.2 R161.2 R167.2
  IN1 w0.102: v1(77.23,79.61) 77.7,80.08 77.7,81.19 78.08,81.58 79.58,81.58 80.24,82.24 83.01,82.24 83.21,82.03 83.47,82.03
  IN1 w0.14: 83.47,82.03 86.05,82.03 89.5,78.58 92.76,78.58 93.42,77.92 94.89,77.92 99.28,73.52 103.84,73.52 v1(104.17,73.85)
  BOTTOM w0.102: v1(77.23,79.61) U7.G16
CORE_V1P15_PWR: length 2.7
  BOTTOM w0.254: U7.AM29 70.64,67 U7.AK30 69.88,67.8 v1(69.53,68.15) ; U7.AK36 v1(66.47,68.14) ; v1(67.21,68.14) 67.59,67.75 U7.AK35
  vias: v1(95.94,67.71)
CR_EN: length 155.8
  TOP w0.108: Q78.2 23.75,31.71 23.5,31.46 20.32,31.46 19.94,31.84 19.94,33.49 21.21,34.76 21.21,40.73 20.76,41.18 20.76,43.7 20.21,44.25 20.21,49.98 21.15,50.92 27.79,50.92 28.75,51.88 28.75,57.14 28.3,57.6 27.81,57.6 26.64,58.77 26.64,59.82 26.72,59.91 26.72,61.97 26.87,62.12 26.87,66.16 27.36,66.64 27.36,71.03 28.68,72.35 31.14,72.35 v1(31.62,71.87)
  IN1 w0.102: 77.62,82.34 76.73,81.45 76.73,77.94 76.91,77.77 77.98,77.77 78.22,78 v1(78.22,78.98)
  IN1 w0.14: 77.62,82.34 79.4,84.12 80.95,84.12 81.51,84.67 81.51,88.33 79.02,90.82 79.02,91.71 78,92.73 69.24,92.73 66.98,90.47 46.28,90.47 46.14,90.6 43.6,90.6 42.8,91.4 42.8,92.93 42.2,93.53 39.53,93.53 36.16,90.16 36.16,87.63 37.97,85.82 37.97,81.63 35.66,79.31 31.27,79.31 30.46,78.5 29.54,78.5 28.68,77.64 28.68,75.36 31.62,72.41 v1(31.62,71.87)
  BOTTOM w0.102: v1(78.22,78.98) 78.15,78.91 U7.L13
D/C#: length 212.3
  TOP w0.203: 141.29,26.89 141.48,26.7 U9.68
  TOP w0.254: 141.29,26.89 v1(140.97,26.89) ; PR10.1 18.84,93.81 19.08,94.05 20.98,94.05 v1(21.08,93.94)
  IN1 w0.254: v1(140.97,26.89) 140.97,27.17 142.98,29.18 142.98,34.26 143.31,34.59 143.31,36.61 146.7,40 147.05,40 147.82,40.76 147.82,41.77 148.69,42.63 149.41,42.63 151.64,44.87 151.64,55.71 150.99,56.36 150.99,67.59 149.38,69.21 148.34,69.21 146.64,70.91 146.64,71.57 143.53,74.68 143.53,78.29 138.9,82.92 131.25,82.92 130.92,82.58 129.19,82.58 127.93,83.84 123.86,83.84 121.71,85.99 121.02,85.99 118.55,88.46 114.02,88.46 113.37,89.11 111.35,89.11 110.7,88.46 107.85,88.46 107.2,89.11 103.75,89.11 102.57,90.3 100.52,90.3 100.16,90.66 97.99,92.83 97.99,95.09 93.95,99.13 93.95,106.26 93.42,106.8 89.56,106.8 86.5,103.74 86.45,103.74 84.34,101.63 68.64,101.63 68.58,101.69 61.82,101.69 60.83,100.69 55.39,100.69 52.94,98.24 47.2,98.24 46.04,97.08 38.06,97.08 34.85,93.87 30.43,93.87 28.35,95.95 23.09,95.95 v1(21.08,93.94)
DDI1_EDP_HPD_R: length 66.9
  TOP w0.108: Q10.3 72.9,100.51 72.05,99.66 69.98,99.66 69.75,99.89 v1(69.75,100.12) 69.75,101.2 R227.2 70.94,102.39 70.94,104.63 70.23,105.34 63.22,105.34 62.74,104.87 62.1,104.87 61.09,103.85 60.62,102.75 59.15,101.28 54.83,101.28 54.01,100.45 54.01,98 52.26,96.25 52.26,94.55 53.06,93.75 55.54,93.75 56.26,93.02 56.26,90.77 v1(55.01,89.51)
  IN1 w0.14: v1(55.01,89.51) 53.75,88.25 53.75,83.23 54.64,82.33 54.64,78.8 56.29,77.15 56.29,76.09 55.93,75.73 55.13,75.73 v1(54.52,76.33)
  BOTTOM w0.102: 58.73,75.05 58.85,75.16 59.14,75.16 U7.R51
  BOTTOM w0.108: 58.73,75.05 57.49,75.05 56.61,75.93 54.9,75.93 54.52,76.32 v1(54.52,76.33)
DDI_1P15_PWR: length 18.6
  TOP w0.508: v1(95.33,67.99) 95.21,67.87 95.21,66.36 C247.2 95.27,66.06 95.44,65.89 95.44,65.41 95.94,64.91 R444.1
  IN1 w0.508: v1(95.33,67.99) 95.17,67.83 92.58,67.83 91.92,68.49 86.79,68.49 86.07,69.22 83.94,69.22
  BOTTOM w0.254: U7.AK21 74.43,67.74 v1(74.81,67.36) 75.19,66.98 U7.AM19 ; U7.AK33 68.36,67.75 v1(67.97,68.14) 67.61,68.5 U7.AJ35
DDI_1P24_PWR: length 14.4
  TOP w0.508: C195.1 66.67,73.89 66.9,73.65 v1(67.21,73.65) ; R354.1 58.42,75.28 58.45,75.25 59.87,75.25 v1(59.92,75.3)
  IN1 w0.508: v1(67.21,73.65) 66.8,73.65 66.18,74.27 62.45,74.27 62.03,73.85 60.88,73.85 59.92,74.81 v1(59.92,75.3)
  BOTTOM w0.254: U7.V36 66.85,74.01 v1(67.21,73.65) 67.21,73.6 U7.Y36
DDR_1P05_PWR: length 11.7
  TOP w0.508: C261.2 85.8,65.06 86.69,64.16 86.69,63.97 87.15,63.51 87.34,63.51 87.42,63.44 91.3,63.44 R425.1 R426.1
  BOTTOM w0.254: U7.AM33 68.37,66.96 v1(68.75,66.58) ; v1(68.75,66.58) 68.97,66.81 69,66.84 U7.AM32 ; v1(68.75,66.58) 68.97,66.34 69.02,66.3 U7.AN32
  vias: v1(73.31,66.59)
DEVSLP0: length 84.4
  TOP w0.254: v1(123.95,66.89) 123.95,66.72 124.26,66.4 124.82,66.4 125.45,67.04 130.57,67.04 131.22,66.39 131.22,66.22 132.25,65.19 132.46,65.19 136.86,60.79 145.27,60.79 146.17,61.69 146.17,62.74 146.7,63.28 147.11,63.28 147.39,62.99 147.39,60.6 v1(147.5,60.49) 147.85,60.14 Q53.1 147.03,59.4 R1025.2
  IN1 w0.254: v1(123.95,66.89) 123.19,66.89 122.51,66.21 115.24,66.21 112,62.97 109.43,62.97 106.64,65.76 102.17,65.76 101.78,65.37 101.05,65.37 99.68,64.01 99.68,63.58 99.82,63.44 99.82,63.11 v1(99.85,63.08)
  BOTTOM w0.102: 86.72,70.57 86.29,70.57 85.41,69.69 84.51,69.69 84.35,69.53 U7.AG1
  BOTTOM w0.108: 86.72,70.57 88.82,70.57 89.8,69.6 92.59,69.6 93.37,68.82 93.37,67.33 R173.2 93.81,66.81 94.51,66.11 94.51,64.66 96.62,62.56 98.25,62.56 98.61,62.19 99.09,62.19 99.8,62.91 99.8,63.03 v1(99.85,63.08)
DEVSLP0_R: length 7.1
  TOP w0.254: R1025.1 R1022.2 147.38,57 147.88,56.49 148.7,56.49 148.87,56.66 Q53.3 149.56,57.37 149.85,57.07 v1(150.17,57.07) R1021.2
DGPU_CL_HDMIP: length 10.6
  TOP w0.508: R274.1 R275.1 R276.1 R277.1 R270.1 R271.1 R272.1 R273.1 16.07,74.61 v1(16.51,75.05) 16.99,75.53 Q19.3
DGPU_EVENT#_Q: length 1.5
  TOP w0.089: TP34.1 77.93,71.85 v1(77.93,71.48)
  BOTTOM w0.102: U7.AD14 v1(77.93,71.48)
