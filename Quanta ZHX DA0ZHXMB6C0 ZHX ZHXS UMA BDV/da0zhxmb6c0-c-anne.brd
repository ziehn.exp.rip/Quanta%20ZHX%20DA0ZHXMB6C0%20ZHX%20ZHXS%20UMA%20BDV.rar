# Allegro board da0zhxmb6c0-c-anne.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_USB_OC1#: length 117.6
  TOP w0.108: v1(129.97,69.83) 130.4,70.26 130.4,71.57 v1(131.69,72.86) 136.44,72.86 138.62,75.05 139.66,75.05 141.18,76.57 141.18,77.22 142.27,78.31 142.27,79.85 142.45,80.03 142.45,80.86 142.7,81.11 142.7,83.89 142.67,83.91 142.67,84.42 142.52,84.57 142.52,86.1 142.83,86.41 146.57,86.41 147.47,87.32 147.47,93.78 149.89,96.2 149.89,97.79 150.75,98.64 151.31,98.64 152.36,99.7 152.54,99.7 153.39,100.55 153.49,100.55 154.08,101.13 v1(154.08,101.49) ; v1(94.62,74.34) 94.64,74.34 94.82,74.51 95.28,74.51 95.73,74.97 95.73,75.39 97.34,77 R98.1
  IN1 w0.102: 83.03,75.78 77.6,75.78 77.33,76.05 v1(77.23,76.05)
  IN1 w0.14: 83.03,75.78 83.56,75.78 84.37,76.6 91.93,76.6 92.19,76.34 92.19,75.51 91.67,75 91.67,74.36 92.18,73.85 93.85,73.85 94.34,74.34 v1(94.62,74.34) 94.64,74.31 94.64,74.01 95.18,73.47 96.37,73.47 96.91,74.02 97.48,74.02 98.53,72.96 106.98,72.96 111.18,68.77 115.34,68.77 115.99,69.42 119.62,69.42 120.26,70.06 121.74,70.06 122.75,69.05 125.74,69.05 126.98,67.81 128.69,67.81 129.97,69.09 v1(129.97,69.83)
  BOTTOM w0.102: v1(77.23,76.05) U7.P16
  BOTTOM w0.108: U1.3 153.41,102.76 153.87,102.3 153.87,101.69 v1(154.08,101.49)
SOC_VCCAPWROK: length 76.4
  IN1 w0.14: v1(108.01,40.88) 107.85,40.72 104.84,40.72 v1(102.77,42.79)
  IN2 w0.089: 71.28,55.16 71.36,55.25 71.36,56.57 70.71,57.23 70.71,58.71 71.48,59.48 71.48,62.65 v1(72.35,63.53)
  IN2 w0.119: v1(102.77,42.79) 102.37,42.79 101.99,42.41 101.15,42.41 100.71,41.97 100.71,36.67 98.42,34.38 89.02,34.38 88.49,34.91 85.65,34.91 84.82,35.75 84.81,35.75 84.77,35.78 80.48,35.78 79.85,36.4 79.69,36.4 79.25,36.84 79.25,43.05 75.71,46.6 75.71,47.49 75.33,47.87 71.35,47.87 70.96,48.27 70.01,49.22 70.01,50.57 70.33,50.9 70.33,52.5 70.7,52.87 70.7,54.58 71.28,55.16
  BOTTOM w0.089: U7.AV26 72.02,63.77 v1(72.35,63.53)
  BOTTOM w0.108: v1(108.01,40.88) 108.01,40.81 108.36,40.47 R457.1
  BOTTOM w0.127: R457.1 C286.1 109.68,39.47 109.97,39.76 Q35.6
SP7_R: length 24.5
  TOP w0.108: v1(100.61,68.37) 100.94,68.7 101.49,68.7 R226.2
  IN1 w0.102: 87.55,68.02 84.39,68.02 83.52,67.15 80.5,67.15 v1(80.09,67.57)
  IN1 w0.14: v1(100.61,68.37) 100.61,67.99 100.28,67.66 97.23,67.66 96.62,67.05 92.69,67.05 91.71,68.02 87.55,68.02
  BOTTOM w0.102: U7.AM10 v1(80.09,67.57)
SP14: length 2.2
  BOTTOM w0.108: U23.22 23.66,26.25 23.29,26.62 22.61,26.62 TP38.1
SPD_A0: length 4.4
  TOP w0.508: U38.1 R174.2 108.92,40.86 108.54,40.48 v1(108.54,39.72) R199.1
SPD_A1: length 7.1
  TOP w0.508: R1194.1 R1192.2 114.79,44.03 114.21,44.62 v1(114.18,44.62) 114.16,44.64 111.53,44.64 110.62,43.73 U38.2
SPD_A2: length 4.4
  TOP w0.508: U38.3 111.89,41.87 112.16,41.6 112.59,41.6 113.01,41.18 R1193.2 v1(113.01,40.08) 112.52,39.59 R197.1
SPD_CLK_SCLK: length 6.9
  TOP w0.108: U38.6 111.89,47.21 112.23,46.87 113.71,46.87 114.45,47.62 114.45,48.78 114.06,49.18 v1(114.06,49.53) 113.72,49.88 R1190.2
SPD_CLK_SDATA: length 5.7
  TOP w0.108: U38.5 113.16,47.22 113.29,47.08 113.62,47.08 114.24,47.71 114.24,47.97 v1(114.04,48.17) 114.22,48.36 114.22,48.66 R1191.2
SPI_HOLD#: length 3.3
  BOTTOM w0.108: R184.2 134.47,43.75 v1(134.47,44.34) 134.47,44.96 135,45.49 U14.7
SPI_PWR: length 26.4
  BOTTOM w0.508: R168.1 R175.1 133.36,56.87 133.1,56.61 133.1,51.77 134.3,50.58 134.3,48.9 133.52,48.12 133.52,47.61 133.73,47.39 U14.8 133.73,45.45 131.79,43.5 R1179.2 C100.2 R184.1 134.11,42.03 133.42,41.34 R176.2 R1162.1 R446.1
SPI_WP#: length 2.2
  BOTTOM w0.108: U14.3 v1(136.27,55.29) R168.2
SRT_CRST#: length 102.2
  TOP w0.102: R58.2 C44.1 146.4,98.77 v1(146.91,98.26)
  IN2 w0.102: v1(76.24,81.03) 76.66,81.45 76.66,83 77.47,83.81 80.57,83.81 80.95,84.19
  IN2 w0.14: 80.95,84.19 81.54,84.78 82,84.78 83.29,86.07 90.83,86.07 v1(91.11,85.79) 92.69,85.79 94.34,84.14 94.34,83.72 94.7,83.35 96.55,83.35 96.65,83.25 97.71,83.25 99.04,81.92 100.48,81.92 101.08,81.33 101.08,80.7 101.7,80.08 104.01,80.08 104.67,79.42 106.32,79.42 106.7,79.8 107.5,79.8 108.51,80.8 113.88,80.8 115.58,79.1 118.13,79.1 118.23,79 119.19,79 119.44,78.76 119.85,78.76 121.16,77.44 121.16,77.34 122.02,76.48 123.36,76.48 123.53,76.65 125.42,76.65 v1(125.82,76.25) ; v1(128.83,84.78) 128.83,84.98 129.21,85.36 137.36,85.36 v1(139.88,87.87)
  BOTTOM w0.102: v1(76.24,81.03) U7.D18 ; Q76.3 91.95,87.97 90.76,86.78 90.76,86.14 v1(91.11,85.79) ; v1(125.82,76.25) 125.82,76.97 126.75,77.9 126.75,78.9 126.08,79.57 126.08,82.3 128.06,84.27 128.58,84.27 128.83,84.52 v1(128.83,84.78) ; v1(146.91,98.26) 147.2,97.97 147.2,95.31 139.88,87.98 v1(139.88,87.87)
SUS_PWRDOWNACK: length 15.8
  BOTTOM w0.102: 86.72,70.79 86.22,70.79 85.33,69.9 84.82,69.9 84.7,70.01 84.25,70.01 84.11,69.88 83.96,69.72 83.71,69.72 83.47,69.96 U7.AE3
  BOTTOM w0.108: 86.72,70.79 88.91,70.79 89.89,69.81 92.68,69.81 93.6,68.89 93.6,68.09 R165.2 93.79,67.57 94.21,67.15 94.21,66.79 95.05,65.95 R164.1
SUSB#: length 252.4
  TOP w0.102: PR235.2 43.36,72 43.44,72.08 v1(43.44,72.53) ; PR236.2 118.09,53.71 v1(117.47,53.71) ; R1163.1 133.01,43.81 133.01,45.57 133.48,46.04 133.48,48.95 v1(133.68,49.16)
  IN1 w0.14: v1(135.24,51.83) 135.24,54.38 133.68,55.95 130.45,55.95 130.39,55.89 127.55,55.89 124.77,53.1 124.77,51.46 124.66,51.36 124.66,50.86 124.31,50.51 121.39,50.51 120.29,51.6 119.36,51.6 117.65,53.31 117.65,53.55 117.5,53.71 v1(117.47,53.71) ; v1(143.17,50.66) 143.32,50.8 143.32,57.72 142.89,58.14 142.89,63.07 141.34,64.63 141.34,68.4 137.43,72.31 137.43,73.28 136.54,74.17 136.54,74.57 135.77,75.34 135.27,75.34 135,75.62 133.84,75.62 132.65,76.81 131.72,76.81 130.4,78.13 127.38,78.13 126.1,79.42 121.28,79.42 119.88,80.82 115.44,80.82 113.35,82.91 109.72,82.91 108.89,83.74 104.38,83.74 v1(104.07,83.43) 102.97,83.43 102.04,84.36 101.35,84.36 100.47,85.23 98.88,85.23 96.66,87.45 95.06,87.45 93.87,88.64 93.11,88.64 89.79,91.96 89.24,91.96 88.37,92.83 88.37,93.88 86.76,95.48 84.45,95.48 83.58,96.35 81.88,96.35 81.47,96.76 77.93,96.76 76.94,97.75 60.85,97.75 59.49,96.39 58.19,96.39 57.02,97.56 54.71,97.56 53.54,96.39 48.39,96.39 47.8,96.39 46.76,95.35 38.78,95.35 35.46,92.03 29.71,92.03 29.01,92.73 24.1,92.73 22.89,91.51 22.89,88.55 23.31,88.12 23.31,88.12 25.23,86.21 25.23,82.56 26,81.78 26,75.46 29.26,72.2 29.53,71.93 29.53,70.91 30.05,70.39 30.87,70.39 31.22,70.04 31.22,68.21 32.05,67.38 32.51,67.38 32.91,66.98 34.42,66.98 34.7,67.25 36.45,67.25 36.75,66.94 38.3,66.94 38.71,67.35 41.81,67.35 42.5,66.67 43.19,66.67 43.74,67.22 43.74,71.7 43.38,72.06 43.38,72.41 43.44,72.46 v1(43.44,72.53)
  IN2 w0.14: v1(133.68,49.16) 134.11,49.16 134.24,49.29 134.24,50.83 v1(135.24,51.83)
  BOTTOM w0.102: R439.1 104.07,83.72 v1(104.07,83.43) 104.42,83.08 R451.2 104.37,82.67 104.14,82.9 103.63,82.9 103.53,83 Q36.3 103.53,84.4 103.15,84.78 R441.1 ; v1(143.17,50.66) 140.5,50.66 139.14,52.02 135.43,52.02 v1(135.24,51.83)
SUSC#: length 92.7
  IN1 w0.14: v1(129.96,77.26) 130.82,77.26 131.58,76.5 132.52,76.5 133.09,75.93 133.09,75.56 133.96,74.69 135.19,74.69 135.2,74.71 135.95,74.71 136.23,74.43 136.23,74.04 137.12,73.15 137.12,72.18 141.02,68.27 141.02,64.5 142.58,62.94 142.58,57.92 143,57.5 143,51.31 142.71,51.02 142.71,50.18 140.85,48.32 140.85,47.27 138.76,45.18 138.76,43.88 137.4,42.52 137.2,42.52 135.86,41.18 135.86,40.26 135.16,39.56 135.16,37.36 134.62,36.82 v1(134.62,35.52)
  IN2 w0.14: v1(129.96,77.26) 129.96,77.26 129.96,77.04 129.24,76.32 126.61,76.32 125.97,76.97 123.4,76.97 123.23,76.79 122.15,76.79 121.48,77.47 121.48,77.57 119.95,79.1 119.55,79.1 119.32,79.32 118.71,79.32 118.62,79.42 115.72,79.42 114.01,81.13 108.39,81.13 107.37,80.11 106.57,80.11 106.19,79.73 104.81,79.73 104.32,80.22 104.32,80.76 104.04,81.04 103.02,81.04 v1(102.54,80.56)
  BOTTOM w0.102: R247.2 132.76,36.19 133.4,36.19 134.06,35.52 v1(134.62,35.52) ; R491.1 102.55,80.55 v1(102.54,80.56) 102.23,80.87 Q36.6 102.23,82.68 101.74,83.16 R453.2 R461.1
SUSD: length 14.4
  TOP w0.508: PQ32.2 v1(112.91,86.27) 112.91,86.59 113.27,86.94 114.35,86.94 114.73,87.32 114.73,88.89 114.25,89.37 113.61,89.37 PQ31.3 114.66,91.95 PR178.2 PR186.2 116.52,91.95 117.13,92.56 PC142.2
SUSON: length 201.9
  TOP w0.203: U9.120 131.5,40.78
  TOP w0.254: PQ30.2 118.62,83.15 118.87,82.9 119.69,82.9 123.5,79.1 123.5,75.28 123.93,74.84 125.09,74.84 125.39,74.54 125.39,73.49 125.34,73.44 125.34,71.64 124.78,71.08 124.78,68.64 125.37,68.05 128.78,68.05 129.67,68.94 130.97,68.94 131.93,67.98 132.54,67.98 v1(133.26,67.26) ; v1(133.66,49.85) 133.52,49.72 133.45,49.72 132.92,49.18 132.92,46.27 132.45,45.8 132.45,43.37 R210.1 131.54,42.47 131.54,40.82 131.5,40.78
  IN1 w0.254: v1(133.26,67.26) 133.26,62.28 136.23,59.32 136.23,51.3 135.68,50.75 134.56,50.75 133.9,50.09 133.9,50.09 v1(133.66,49.85) 133.55,49.85 132.92,49.22 132.92,49.07 129.37,45.51 127.34,45.51 127.13,45.3 127.13,45.3 125.31,43.48 125.31,39.97 123.22,37.89 122.03,37.89 121.33,37.19 117.7,37.19 116.89,36.39 114.2,36.39 111.55,33.73 107.3,33.73 105.78,32.21 98.28,32.21 97.83,31.76 97.15,31.76 96.91,32 93.69,32 92.39,30.7 78.11,30.7 77.4,30 41.58,30 39.92,31.66 37.76,31.66 33.37,36.05 33.37,43.75 34.88,45.27 35.12,45.27 35.42,45.57 35.42,45.95 35.42,45.95 35.42,46.66 36.56,47.8 36.56,53.15 34.79,54.93 34.49,54.93 33.76,55.67 v1(33.76,56.4)
  BOTTOM w0.254: PR121.2 v1(31.2,54.8) 32.36,54.8 33.76,56.2 v1(33.76,56.4)
SUSPWRDANCK: length 78.8
  TOP w0.108: v1(121.31,68.54) 121.64,68.88 122.09,68.88 123.87,70.65 123.87,71.45 124.43,72.01 124.43,72.49 124.19,72.74 123.63,72.74 122.32,74.05 122.32,74.97 122.71,75.37 122.71,76.9 122.44,77.17 122.44,78.87 119.32,82 118.36,82 116.75,83.61 v1(116.67,83.61)
  IN1 w0.14: v1(116.67,83.61) 113.92,86.36 105.04,86.36 104.39,87.01 102.88,87.01 102.05,87.84 99.86,87.84 v1(99.67,87.66) ; v1(97.87,63.72) 97.92,63.77 97.92,64.25 97.99,64.33 97.99,64.58 97.42,65.16 97.42,65.26 97.15,65.53 97.15,65.92 97.42,66.19 98.05,66.19 98.5,66.63 99.95,66.63 100.32,67.01 100.74,67.01 103.34,69.61 107.93,69.61 110.3,67.23 112.63,67.23 113.34,67.94 115.69,67.94 115.79,67.84 120.91,67.84 121.31,68.24 v1(121.31,68.54)
  BOTTOM w0.108: v1(99.67,87.66) 99.61,87.72 R163.2 99.07,88.08 99.29,88.3 Q32.1 100.59,88.88 R420.1 ; v1(97.87,63.72) 97.79,63.64 97.54,63.64 97.46,63.57 95.91,63.57 95.05,64.43 R164.2
SUSPWRDANCK_EC: length 116.6
  TOP w0.127: U9.80 141.53,31.5 141.22,31.19 137.84,31.19 136.95,32.07 134.8,32.07 v1(134.24,31.51) ; v1(118.31,80.01) 118.31,80.86 117.14,82.03 112.34,82.03 111.59,82.78 111.59,86.11 111.12,86.57 111.12,89.88 110.03,90.97 104.75,90.97 100.61,95.12 100.61,98.03 102.46,99.89 103.63,99.89 104.32,100.57 v1(104.9,100.57) 105.54,100.57 105.74,100.37 106.25,100.37 106.67,100.79 PR133.1
  IN1 w0.127: v1(118.31,80.01) 118.59,80.29 119.69,80.29 121.07,78.9 125.88,78.9 127.23,77.55 127.23,77.16 127.65,76.74 130.61,76.74 131.37,75.98 132.31,75.98 132.58,75.71 132.58,75.35 134.31,73.62 135.15,73.62 136.6,72.17 136.6,71.45 137.56,70.49 137.56,69.66 140.51,66.72 140.51,64.28 142.06,62.73 142.06,57.71 142.49,57.29 142.49,51.52 142.2,51.23 142.2,50.4 140.31,48.51 140.31,47.46 138.25,45.4 138.25,44.09 137.19,43.03 136.99,43.03 135.34,41.39 135.34,40.47 134.65,39.77 134.65,37.76 134.04,37.15 134.04,34.27 134.31,34 134.31,31.58 v1(134.24,31.51)
SVID_ALERT#_SOC: length 24.5
  IN2 w0.102: v1(65.51,71.39) 65.42,71.39 65.02,71.8 64.68,71.8 64.44,71.56 64.44,71.26 63.83,70.64 59.02,70.64 58.42,71.24 58.3,71.24 58.3,71.24 56.95,71.24 56.64,70.93 54.72,70.93 54.41,71.24 54.13,71.24
  IN2 w0.14: v1(44.96,70.95) 44.97,70.94 46.98,70.94 47.91,71.86 51.17,71.86 51.8,71.24 54.13,71.24
  BOTTOM w0.102: U7.AD40 65.51,71.28 v1(65.51,71.39) ; R143.1 44.4,70.95 v1(44.96,70.95) 45.22,70.95 R142.2
SVID_CLK_SOC: length 24
  IN2 w0.102: 54.55,71.55 54.97,71.13 56.2,71.13 56.52,71.44 58.38,71.44 58.39,71.44 58.62,71.44 59.22,70.84 63.59,70.84 64.03,71.28 v1(64.03,71.42)
  IN2 w0.14: v1(44.96,71.59) 46.9,71.59 47.69,72.38 51.16,72.38 51.99,71.55 54.55,71.55
  BOTTOM w0.102: R148.1 44.33,72.48 44.49,72.64 v1(44.62,72.64) 44.82,72.64 44.96,72.5 v1(44.96,71.59) R147.1 ; v1(64.03,71.42) 64.03,71.28 63.78,71.04 U7.AD42
SVID_DATA_SOC: length 26.6
  IN2 w0.102: v1(64.85,71.39) 65.23,71.01 65.23,70.86 65.1,70.73 64.34,70.73 64.24,70.63 64.24,70.5 64.34,70.4 64.88,70.4 64.98,70.3 64.98,70.16 64.88,70.06 63.45,70.06 63.07,70.44 58.79,70.44 58.19,71.04 57.08,71.04 56.77,70.72 54.62,70.72 54.46,70.88 53.92,70.88
  IN2 w0.14: 53.92,70.88 51.7,70.88 51.04,71.54 48.04,71.54 47.12,70.62 45.32,70.62 v1(45,70.3)
  BOTTOM w0.102: U7.AD41 64.49,71.06 64.82,71.39 v1(64.85,71.39) ; R139.1 44.94,70.3 v1(45,70.3) 45.59,69.71 R138.2
SYS_HWPG: length 105.1
  TOP w0.203: U9.20 127.48,30.3
  TOP w0.254: 127.48,30.3 127.89,30.71 129.58,30.71 131.67,32.8 131.67,35.22 v1(133.25,36.79) ; v1(138.46,97.5) 137.08,96.13 136.55,96.13 135.96,95.54 135.96,93.72 135.36,93.11 135.36,88.94 131.24,84.82 131.24,83.35 130.22,82.33 130.22,78.88 131.28,77.81 131.28,76.36 v1(132.12,75.52) ; v1(141.35,54.83) 140.92,55.26 137.11,55.26 136.74,55.64 R1195.2 133.65,57.24 133.02,56.61 D18.1
  IN1 w0.254: v1(132.12,75.52) 132.12,75.34 134.17,73.29 135.02,73.29 136.27,72.03 136.27,71.31 137.23,70.35 137.23,69.52 140.17,66.58 140.17,64.06 141.73,62.51 141.73,57.23 141.35,56.84 v1(141.35,54.83) 141.6,54.83 141.87,54.57 141.87,50.53 139.98,48.65 139.98,47.64 137.92,45.58 137.92,44.23 137.05,43.36 136.85,43.36 135.01,41.53 135.01,40.61 133.25,38.84 v1(133.25,36.79)
  IN2 w0.254: v1(138.46,97.5) 138.23,97.73 136.27,97.73 135.69,98.31 135.69,99.96 v1(136.27,100.55)
  BOTTOM w0.254: PR67.2 v1(135.94,101.72) 136.27,101.39 v1(136.27,100.55) ; PR24.2 PR156.2 137.97,97.02 v1(138.46,97.5)
SYS_SHDN#: length 154.5
  TOP w0.254: v1(138.69,96.23) 138.69,96.61 138.99,96.92 138.99,97.7 138.69,98.01 138.25,98.01 136.75,96.51 135.97,96.51 135.87,96.41 134.75,96.41 134.65,96.51 133.62,96.51 PR168.2 132.46,96.01 132.46,96.19 130.4,98.25 130.4,100.2 130.96,100.76 132.79,100.76 133.34,101.31 133.34,102.21 134.91,103.78 135.28,103.78 136.63,105.13 136.63,107.67 137.64,108.67 137.64,111.32 137.21,111.76 v1(137.15,111.76) ; v1(122.81,35.23) 122.81,35.23 121.75,36.29 120.34,36.29 120.28,36.24 PQ16.3 ; v1(147.4,28.73) 147.08,29.05 R1204.2
  IN1 w0.254: v1(139.4,91.1) 141.05,91.1 143.08,93.13 143.89,93.13 145.63,91.4 145.63,83.86 145.17,83.41 145.17,79.14 145.38,78.93 145.38,77.06 146.03,76.41 146.03,75.25 147.58,73.7 147.58,71.3 148.7,70.18 149.84,70.18 151.93,68.09 151.93,56.75 152.58,56.1 152.58,39.46 150.56,37.44 149.64,37.44 148.69,36.48 148.69,35.04 148.35,34.7 148.35,33.12 147.96,32.73 146.85,32.73 146.59,32.48 146.59,29.53 v1(147.4,28.73)
  IN2 w0.254: v1(122.81,35.23) 124.95,33.09 125.98,33.09 126.19,32.87 126.19,30.82 130,27.01 133.63,27.01 133.63,27.02 135.61,27.02 136.53,26.1 v1(136.53,25.9)
  BOTTOM w0.254: PR77.2 v1(137.15,111.76) ; v1(147.4,28.73) 147.4,27.43 145.59,25.62 136.81,25.62 v1(136.53,25.9) ; v1(138.69,96.23) 138.69,95.88 137.91,95.1 PR157.1 138.66,95.09 138.86,95.29 139.57,95.29 139.93,94.94 139.93,91.63 v1(139.4,91.1)
TEMP_MBAT: length 91.2
  TOP w0.127: PR227.2 68.05,20.38 67.25,20.38 67.08,20.21 v1(67.08,19.88) PR223.1 ; v1(144.32,28.06) 143.68,28.7 U9.73
  IN1 w0.127: v1(123.01,22.88) 123.06,22.82 124.16,22.82 124.81,23.47 127.07,23.47 128.22,22.32 137.06,22.32 137.76,23.02 142.31,23.02 144.91,25.62 144.91,27.47 v1(144.32,28.06)
  BOTTOM w0.127: v1(67.08,19.88) 67.58,19.38 67.91,19.38 69.53,17.76 83.85,17.76 84.8,16.81 100.06,16.81 103.74,20.5 116.56,20.5 117.39,21.33 120.68,21.33 121.69,22.34 122.48,22.34 v1(123.01,22.88)
THER_CPU: length 2.5
  BOTTOM w0.108: R78.1 88.6,90.99 v1(88.6,91.61) 88.31,91.89 R69.2
THERMDA: length 3.8
  BOTTOM w0.108: TP6.1 103.14,68.3 103.14,66.53 102.83,66.22 U8.2
THERMDC: length 3.8
  BOTTOM w0.108: TP5.1 101.86,68.87 102.92,67.81 102.92,67 102.79,66.87 U8.3
THRM_MOINTOR: length 131.9
  TOP w0.108: R255.2 123.31,25.49 v1(122.76,25.49) 122.45,25.49 122.18,25.77 122.18,26.53 121.39,27.32 121.39,29.07 120.79,29.67 120.79,29.77 120.09,30.47 118.31,30.47 117.18,31.6 116.87,31.6 v1(116.46,32.01)
  IN1 w0.14: v1(116.46,32.01) 117.08,32.63 123.17,32.63 124.41,31.38 126.39,31.38 128.7,33.7 128.7,37.58 128.12,38.16 128.12,39.16 128.55,39.59 132.17,39.59 133.73,41.14 133.73,42.06 135.98,44.31 135.98,45.55 137.77,47.35 137.77,48.26 140.32,50.81 140.32,57.15 140.81,57.64 140.81,62.14 139.22,63.73 139.22,66.22 136.34,69.1 136.34,69.98 135.38,70.94 135.38,71.61 134.6,72.39 133.78,72.39 130.92,75.26 129.38,75.26 128.73,75.91 127.3,75.91 126.17,77.04 123.83,77.04 122.8,78.07 120.71,78.07 120.01,78.77 118.06,78.77 117.5,79.33 115.3,79.33 113.45,81.18 109.92,81.18 109.28,81.83 108.44,82.66 105.91,82.66 105.24,81.98 104.82,81.98 104.52,82.29 102.58,82.29 101.59,83.28 100.9,83.28 100.02,84.15 98.43,84.15 96.63,85.95 95.5,85.95 95.08,86.37 94.34,86.37 93.9,86.81 93.26,86.81 92.14,87.93 92.14,88.09 89.53,90.69 89.08,90.69 v1(88.9,90.52)
  BOTTOM w0.108: v1(88.9,90.52) 88.9,90.49 88.14,89.72 R78.2 C51.2 86.73,89.72 R79.1
TON_VCORE: length 2.9
  BOTTOM w0.203: 38.05,67.02 38.15,66.92 PU4.16
  BOTTOM w0.254: PR37.2 37.1,68.11 37.8,68.11 38.05,67.86 38.05,67.02
TON_VGG: length 3.9
  TOP w0.203: PU6.16 125.45,54.07 125.65,54.27 125.65,54.5
  TOP w0.254: PR193.2 125.94,55.31 v1(125.38,55.31) 125.38,54.78 125.65,54.5
TOUCH_SCREEN_PWR:
  vias: v1(66.8,97.27) v1(67.41,100.09) v1(67.45,97.27)
TP_EN_EC: length 133.3
  TOP w0.108: U9.78 143.36,30.7 144.17,31.51 144.63,31.51 144.81,31.69 v1(147.12,31.69) ; v1(39.52,20.56) 40,20.09 R587.1 C594.1
  IN1 w0.14: v1(147.12,31.69) 147.11,30.73 147.6,30.24 148.21,30.24 148.51,29.94 148.51,28.65 146.56,26.7 146.56,22.77 145.24,21.45 142.71,21.45 141.48,20.22 125.87,20.22 125.6,19.96 103.91,19.96 100.47,16.51 74.36,16.51 73.61,17.25 73.61,17.71 73.61,19.41 70.13,22.9 57.41,22.9 56.67,23.64 51.44,23.64 48.81,21.01 46.12,21.01 45.14,20.03 40.06,20.03 v1(39.52,20.56)
TP_EN_EC_C: length 3.8
  TOP w0.108: v1(41.02,20.58) 40.78,20.34 R587.2
  BOTTOM w0.108: v1(41.02,20.58) 41.57,20.58 42.17,21.17 42.8,21.17 43.1,21.47 CN12.8
TP_INT#: length 270.9
  TOP w0.108: R39.1 96.32,77.57 v1(95.12,76.37) ; v1(129.93,70.66) v1(129.93,71.57) 129.93,71.85 130.99,72.91 130.99,77.69 129.93,78.76 v1(129.93,83.37) ; Q42.3 v1(38.5,22.7)
  IN1 w0.102: 83.57,81.45 82.91,81.45 82.65,81.7 81.02,81.7 v1(80.45,81.13)
  IN1 w0.14: v1(129.93,70.66) 129.93,70.44 129.43,69.94 129.43,68.94 128.57,68.09 127.1,68.09 125.86,69.33 122.87,69.33 121.86,70.34 120.14,70.34 119.51,69.7 115.88,69.7 115.23,69.05 111.29,69.05 107.1,73.24 98.65,73.24 97.59,74.3 96.86,74.3 95.96,75.2 95.3,75.2 95.12,75.38 v1(95.12,76.37) 94.13,77.36 93.17,77.36 92.51,78.02 89.27,78.02 85.84,81.45 83.57,81.45 ; v1(129.93,83.37) 130.38,82.92 130.78,82.92 131.11,83.26 139.04,83.26 143.86,78.43 143.86,74.82 146.98,71.71 146.98,71.05 148.45,69.57 149.48,69.57 151.33,67.73 151.33,56.5 151.98,55.85 151.98,44.73 149.55,42.3 148.83,42.3 148.16,41.63 148.16,40.62 147.19,39.66 146.84,39.66 145.21,38.03 145.21,33.54 145.98,32.77 145.98,25.52 141.24,20.78 125.64,20.78 125.37,20.51 103.68,20.51 100.23,17.07 74.59,17.07 74.17,17.48 74.17,19.64 70.36,23.46 57.64,23.46 56.9,24.2 51.21,24.2 48.58,21.57 39.62,21.57 v1(38.5,22.7)
  BOTTOM w0.102: v1(80.45,81.13) 80.6,80.98 80.6,80.36 U7.E8
TP_INT_C: length 16.2
  TOP w0.108: R80.1 v1(89.13,84.75) 88.44,84.07 88.44,83.32 v1(87.92,82.8)
  IN2 w0.14: v1(79.21,78.75) 79.78,79.33 79.78,81.21 80.76,82.19 82.62,82.19 83.93,83.51 85.32,83.51 86.38,82.44 87.56,82.44 v1(87.92,82.8)
  BOTTOM w0.102: U7.J12 78.99,78.54 v1(79.21,78.75)
TP_INT_EC#: length 164.2
  TOP w0.108: Q44.3 43.56,21.58 v1(43.41,21.43) R505.1 43.29,20.56 v1(43.77,20.56) ; R435.1 126.45,42.1 128.19,42.1 v1(128.63,41.66) 128.3,41.66 128.13,41.49 128.13,40.57 128.3,40.4 U9.128
  IN1 w0.14: v1(43.77,20.56) 44.49,21.29 48.7,21.29 51.33,23.92 56.79,23.92 57.53,23.18 70.24,23.18 73.89,19.53 73.89,17.6 73.89,17.37 74.47,16.79 100.35,16.79 103.8,20.24 125.48,20.24 125.75,20.5 141.36,20.5 146.26,25.4 146.26,33.34 146.53,33.61 146.53,35.18 150.78,39.42 150.78,41.1 v1(150.56,41.32)
  IN2 w0.14: v1(128.63,41.66) 129.01,41.28 129.01,40.57 129.86,39.72 134.05,39.72 134.85,38.93 143.29,38.93 145.85,41.48 148.07,41.48 148.74,40.81 149.28,40.81 149.78,41.32 v1(150.56,41.32)
TP_POWER_ON: length 132.1
  TOP w0.108: v1(128.84,44.61) 128.84,44.21 128.91,44.14 R1167.1
  IN1 w0.14: v1(51.88,28.25) 52.08,28.05 54.87,28.05 55.12,28.3 61.7,28.3 62.35,27.65 74.88,27.65 75.64,28.41 78.05,28.41 79.05,29.4 93.28,29.4 94.33,30.46 96.15,30.46 96.85,29.75 102.62,29.75 105.06,27.32 105.06,26.29 107.28,24.06 107.28,23.55 108.01,22.83 114.87,22.83 115.57,23.52 117.22,23.52 118.43,24.73 124.01,24.73 124.2,24.93 127.67,24.93 128.82,23.78 136.31,23.78 139.78,27.25 139.78,30.41 140.73,31.35 140.73,32.67 141.44,33.38 141.44,34.9 141.76,35.22 141.76,38.25 142.52,39.01 142.52,41.47 v1(142.71,41.66)
  IN2 w0.14: v1(142.71,41.66) 142.27,42.1 140,42.1 v1(139.14,41.25) 138.66,41.73 138.66,42.65 137.97,43.34 132.55,43.34 132.5,43.29 130.31,43.29 129.99,43.6 129.48,43.6 128.84,44.24 v1(128.84,44.61)
  BOTTOM w0.108: v1(139.14,41.25) 139.19,41.2 R1157.1 ; v1(51.88,28.25) 51.88,28.23 R497.1
TP_RST#_Q: length 13.6
  TOP w0.108: R101.1 92.15,81.63 v1(92.15,82.39)
  IN2 w0.14: v1(81.52,80.21) 82.02,80.71 82.02,81.32 82.3,81.61 83.09,81.61 83.37,81.88 88.25,81.88 89.04,82.67 91.87,82.67 v1(92.15,82.39)
  BOTTOM w0.102: U7.F7 v1(81.52,80.21)
TP_SENSOR_INT_C: length 3.5
  TOP w0.108: v1(42.47,20.69) 42.53,20.69 R588.2
  BOTTOM w0.108: CN12.7 44.1,21.18 43.94,21.02 43.56,21.02 43.23,20.69 v1(42.47,20.69)
TP_SENSOR_INT_R: length 11.9
  TOP w0.108: Q44.1 45.59,24.4 45.84,24.64 R495.1 43.86,24.98 v1(43.82,24.94) 43.62,24.94 43.03,24.35 Q41.2 41.61,24.35 41.28,24.02 41.28,22.42 41.65,22.05 R505.2 41.65,20.34 41.96,20.03 R588.1 C320.1
TPCLK: length 127.3
  TOP w0.102: v1(145.97,33.96) 144.39,33.96 143.25,35.1 U9.89 ; v1(47.37,19.79) 47.35,19.77 R513.2 C330.2
  IN2 w0.14: v1(47.37,19.79) 47.38,19.78 48.14,19.78 51.88,23.52 56.62,23.52 63.88,16.27 99.66,16.27 103.55,20.16 144.94,20.16 146.19,21.42 146.19,33.73 v1(145.97,33.96)
  BOTTOM w0.102: CN12.2 49.1,20.69 48.19,19.79 v1(47.37,19.79)
TPDATA: length 133.9
  TOP w0.102: C329.2 R512.2 45.05,19.77 44.88,19.6 v1(44.88,19.12) ; U9.90 143.28,35.5 144.41,34.37 146.3,34.37 147.07,33.6 v1(147.1,33.6)
  IN2 w0.14: v1(147.1,33.6) 146.54,33.04 146.54,21.23 145.12,19.82 103.69,19.82 99.8,15.93 63.73,15.93 56.48,23.18 52.02,23.18 48.01,19.17 44.93,19.17 v1(44.88,19.12)
  BOTTOM w0.102: CN12.3 48.1,20.96 47.88,20.74 47.45,20.74 45.82,19.12 v1(44.88,19.12)
TPM_SERIRQ: length 7.6
  BOTTOM w0.108: U13.27 129.14,76.82 128.83,77.14 v1(128.83,79.03) R1013.2 127.48,80.38 127.48,80.89 127.56,80.98 U11.4
TPM_VDD: length 28
  TOP w0.508: v1(128.47,71.47) 128.48,71.48 128.48,73.89 v1(128.65,74.06) 128.66,74.06 v1(129.29,74.68) 128.41,75.56 v1(128.41,77.31)
  IN1 w0.508: v1(129.29,74.68) 129.3,74.69 130.83,74.69 133.98,71.54 v1(134.75,71.54)
  IN2 w0.508: v1(127.19,68.66) 127.24,68.71 127.24,69.67 127.76,70.2 127.76,71.14 128.08,71.45 128.46,71.45 v1(128.47,71.47)
  BOTTOM w0.254: U11.6 127.44,82.28 127.21,82.05
  BOTTOM w0.305: C97.1 129.52,71.62 U13.19
  BOTTOM w0.508: v1(127.19,68.66) 127.21,68.69 R1201.1 ; v1(128.41,77.31) 128.41,78.21 126.9,79.72 126.9,81.74 127.21,82.05 ; R135.2 127.73,71.47 v1(128.47,71.47) 128.61,71.6 128.69,71.6 128.94,71.86 C97.1
TPM_VSB: length 8.4
  BOTTOM w0.254: R159.1 R149.2 141.35,73.43 140.83,73.95 v1(140.83,74.89) C92.2 140.01,75.65 C94.1 139.34,74.97 138.05,74.97 137.95,74.87 U13.5
TS_EN: length 124.6
  TOP w0.108: v1(133.19,35.75) 134.89,34.05 135.29,34.05 137.93,31.41 141.05,31.41 141.53,31.9 U9.81
  IN1 w0.14: v1(82.75,95.1) 84.1,95.1 84.39,94.81 86.7,94.81 87.81,93.7 87.81,92.65 89.03,91.44 89.58,91.44 92.89,88.12 93.66,88.12 94.85,86.93 95.31,86.93 95.73,86.51 96.86,86.51 98.66,84.71 100.25,84.71 101.13,83.84 101.82,83.84 102.76,82.9 104.32,82.9 104.64,83.22 108.68,83.22 110.16,81.74 113.75,81.74 115.6,79.89 117.73,79.89 118.29,79.33 120.25,79.33 120.96,78.63 123.04,78.63 124.07,77.6 126.4,77.6 127.53,76.47 130.5,76.47 134.02,72.95 134.88,72.95 135.93,71.89 135.93,71.18 136.9,70.21 136.9,69.38 139.84,66.44 139.84,63.9 141.39,62.35 141.39,57.36 140.88,56.85 140.88,50.58 138.33,48.03 138.33,47.12 137.19,45.97 137.19,44.53 136.75,44.09 136.55,44.09 134.28,41.83 134.28,40.91 132.39,39.02 132.39,36.29 132.93,35.75 v1(133.19,35.75)
  BOTTOM w0.108: R1000.1 C596.2 v1(79.29,93.22) 81.48,95.42 82.43,95.42 v1(82.75,95.1)
TS_EN_R: length 2.8
  BOTTOM w0.108: R1000.2 77.48,94 v1(77.62,94.15) 78.25,94.77 CN10.35
TS_USB+: length 144.8
  TOP w0.102: v1(75.58,99.42) 76.01,99.42 76.12,99.31 76.12,98.47 76.04,98.38 75.68,98.38 R118.1
  IN2 w0.14: v1(31.74,60.57) 32,60.57 32.1,60.47 32.1,60.25 31.83,59.98 31.55,59.98 31.26,60.26 30.91,60.26 30.13,61.05 27.05,61.05 19.76,53.76 15.36,53.76 15.11,54.01 15.11,58.98 18.75,62.63 19.18,62.63 22.9,66.35 22.9,71.68 19.18,75.39 16.02,75.39 14.5,76.91 14.5,82.18 14.16,82.52 14.16,84.03 15.16,85.03 15.16,87.11 14.24,88.03 14.24,89.22 15.55,90.52 15.55,93.57 19.83,97.86 26.93,97.86 29.63,95.15 34.35,95.15 36.13,96.93 41.19,96.93 42.18,97.92 51.21,97.92 52.02,97.11 55.9,97.11 57.5,95.51 60.79,95.51 64.09,98.8 69.22,98.8 69.78,99.37 70.63,99.37 71.25,99.99 75.85,99.99 76.09,99.75 76.09,99.61 75.89,99.42 v1(75.58,99.42)
  BOTTOM w0.102: v1(31.74,60.57) 32.06,60.57 32.26,60.77 32.26,61.52 32.17,61.61 32.17,62.28 32.06,62.39 31.94,62.39 31.64,62.09 U35.7
TS_USB+_I2CCL: length 2.8
  TOP w0.102: v1(75.64,96.87) 75.76,96.87 75.92,97.02 75.92,97.6 75.75,97.77 R118.2
  BOTTOM w0.102: v1(75.64,96.87) 75.76,96.87 75.92,96.71 75.92,96.56 75.75,96.39 CN10.30
TS_USB-: length 144.9
  TOP w0.102: v1(76.52,99.43) 76.33,99.24 76.33,98.76 R119.1
  IN2 w0.14: v1(76.52,99.43) 76.36,99.59 76.36,99.86 75.96,100.26 71.14,100.26 70.52,99.63 69.67,99.63 69.11,99.07 63.98,99.07 60.68,95.77 57.61,95.77 56.01,97.37 52.13,97.37 51.32,98.19 42.07,98.19 41.08,97.2 36.02,97.2 34.24,95.42 29.74,95.42 27.04,98.12 19.72,98.12 15.28,93.68 15.28,90.63 13.98,89.33 13.98,87.92 14.9,87 14.9,85.14 13.89,84.14 13.89,82.41 14.24,82.07 14.24,76.79 15.91,75.12 19.07,75.12 22.63,71.57 22.63,66.46 19.07,62.89 18.64,62.89 14.84,59.09 14.84,53.9 15.25,53.5 19.87,53.5 27.16,60.79 30.01,60.79 30.8,60 31.15,60 31.43,59.72 31.94,59.72 32.37,60.14 32.37,60.32 v1(32.63,60.58)
  BOTTOM w0.102: v1(32.63,60.58) 32.46,60.74 32.46,61.61 32.37,61.7 32.37,62.37 32.15,62.59 U35.6
TS_USB-_I2CDA: length 2.8
  TOP w0.102: R119.2 76.26,97.77 76.12,97.63 76.12,97.04 76.3,96.87 v1(76.4,96.87)
  BOTTOM w0.102: CN10.31 76.25,96.44 76.12,96.56 76.12,96.74 76.25,96.87 v1(76.4,96.87)
TSEN_VCORE: length 7.2
  BOTTOM w0.203: 37.9,64.92 PU4.11
  BOTTOM w0.254: 37.9,64.92 37.15,64.92 36.81,65.26 PR173.2 36.31,65.01 35.79,65.01 35.62,64.84 34.43,64.84 PC54.1 33.9,65.63 33.21,66.33 PR50.2
TSEN_VGG: length 5.7
  TOP w0.203: PU6.11 126.2,52.07 v1(126.26,52.01)
  BOTTOM w0.254: v1(126.26,52.01) 126.26,52.46 126.5,52.7 127.33,52.7 127.76,53.13 PC72.1 PR198.2 PR199.2
UART1_RXD: length 4.4
  TOP w0.089: v1(79.31,71.47) 79.7,71.86 80.35,71.86 80.53,72.03 82.44,72.03 TP30.1
  BOTTOM w0.102: v1(79.31,71.47) U7.AD12
UART1_TXD: length 6.3
  TOP w0.089: 83.21,72.06 83,71.85 82.76,71.85 82.76,71.85 80.6,71.85 80.2,71.46 v1(80.02,71.46)
  TOP w0.108: 83.21,72.06 83.3,72.15 TP32.1
  BOTTOM w0.102: U7.AD10 80.02,71.26 v1(80.02,71.46)
UGATE_VCORE: length 5.5
  IN1 w0.762: v2(40.01,72.1) 40.64,71.47 40.64,70.2 41.63,69.21 41.63,68.82 v2(42.74,67.72)
  vias: v1(40.06,71.42)
UGATE_VGG: length 13.5
  IN2 w0.762: v2(120.7,54.65) 120.24,55.12 120.24,55.78 120.79,56.34 120.79,58.98 125.71,63.9 v2(125.71,65.67)
  vias: v1(120.19,55.11)
ULT_EDP_HPD: length 7.4
  TOP w0.108: Q10.2 v1(73.92,100.93) 73.92,100.52 73.38,99.99 72.75,99.99 71.88,99.13 R378.2 C698.1 R819.1
USB2_1P24_PWR: length 7.4
  TOP w0.508: v1(63.55,78.91) 62.02,77.38 C153.2 60.43,77.38 C162.2 59.8,77.76 59.41,78.15 59.41,78.9 59.01,79.3 R312.1
  BOTTOM w0.254: v1(63.55,78.91) 63.33,78.91 U7.H44
USB2_OBSP: length 2.5
  TOP w0.108: v1(63.52,81.04) 63.49,81.07 R333.1
  BOTTOM w0.102: U7.B46 62.14,81.56 62.66,81.04 v1(63.52,81.04)
USB3_OBSN: length 2.6
  TOP w0.108: v1(68.48,80.32) 69.04,80.87 69.04,81.57 R343.2
  BOTTOM w0.102: v1(68.48,80.32) 68.13,79.96 U7.F34
USB3_OBSP: length 1.8
  TOP w0.108: R343.1 68.82,81.63 68.82,81.22 68.59,80.99 v1(68.48,80.99)
  BOTTOM w0.102: v1(68.48,80.99) 68.13,80.64 U7.D34
USB30_RX0+: length 103.2
  IN2 w0.14: v1(70.41,79.7) 70.41,79.84 70.29,79.96 70.12,79.96 69.14,78.98 69.14,77.91 65.96,74.73 62.45,74.73 61.23,75.95 59.59,75.95 58.36,77.18 58.36,77.18 58.33,77.15 55.68,77.15 53.51,79.32 53.51,81.58 52.39,82.71 52.39,85.66 49.09,88.95 46.6,88.95 46.31,89.25 39.12,89.25 38.18,88.31 29.05,88.31 27.76,87.02 25.84,87.02 25.02,86.2 25.02,80.38 23.84,79.2 22.9,79.2 22.58,78.89 22.58,77.24 26.17,73.64 26.17,62.21 20.7,56.73 18.85,56.73 18.58,57 17.87,57 17.65,56.79 17.65,55.64 17.42,55.4 17.16,55.4 v1(16.81,55.06)
  BOTTOM w0.102: U7.F28 70.74,80.04 70.61,80.04 70.41,79.85 v1(70.41,79.7) ; R12.2 16.67,53.85 16.84,53.68 17.14,53.68 17.4,53.94 17.4,55.28 17.24,55.44 17.19,55.44 v1(16.81,55.06)
USB30_RX0+_R: length 8.5
  BOTTOM w0.102: R12.1 15.89,53.98 15.75,53.84 15.35,53.84 D26.1 14.65,53.86 14.51,53.86 14.35,54.02 14.35,56.23 13.56,57.01 12.79,57.01 12.13,56.35 11.8,56.35 11.7,56.45 CN1.6
USB30_RX0-: length 103.2
  IN2 w0.14: v1(16.81,56.02) 17.16,55.67 17.31,55.67 17.39,55.75 17.39,56.9 17.76,57.27 18.69,57.27 18.96,57 20.59,57 25.91,62.32 25.91,73.53 22.31,77.13 22.31,79 22.78,79.47 23.73,79.47 24.75,80.49 24.75,86.31 25.73,87.29 27.65,87.29 28.94,88.57 38.07,88.57 39.01,89.51 46.42,89.51 46.71,89.22 49.2,89.22 52.66,85.77 52.66,82.82 53.78,81.69 53.78,79.43 55.79,77.42 58.46,77.42 59.69,76.19 61.33,76.19 62.55,74.97 65.86,74.97 68.9,78.01 68.9,79.08 70.02,80.2 70.2,80.2 v1(70.41,80.41)
  BOTTOM w0.102: U7.D28 70.5,80.49 v1(70.41,80.41) ; v1(16.81,56.02) 17.19,55.64 17.33,55.64 17.6,55.37 17.6,53.86 17.22,53.48 16.92,53.48 R11.2
USB30_RX0-_R: length 8.5
  BOTTOM w0.102: CN1.5 11.7,56.05 11.8,56.15 12.21,56.15 12.87,56.81 13.48,56.81 14.15,56.14 14.15,53.94 14.43,53.66 14.59,53.66 D25.1 15.36,53.64 15.7,53.64 15.89,53.44 R11.1
USB30_TX0+: length 99.2
  IN2 w0.14: v1(68.16,83.42) 68.28,83.42 68.45,83.25 68.45,82.25 67.74,81.55 67.74,77.64 65.76,75.66 62.78,75.66 61.52,76.91 59.93,76.91 58.64,78.21 56.13,78.21 55.21,79.13 55.21,81.41 53.44,83.17 53.44,86.23 50.21,89.46 50.21,89.87 49.62,90.46 37.04,90.46 35.94,89.36 28.59,89.36 27.32,88.09 25.41,88.09 23.97,86.64 23.97,80.83 23.39,80.25 22.43,80.25 21.48,79.3 21.48,76.84 25.12,73.2 25.12,64.07 21.09,60.04 19.56,60.04 19.41,60.2 v1(19.41,60.29)
  BOTTOM w0.102: v1(19.41,60.29) 19.3,60.19 18.58,60.19 18.45,60.32 C21.1 ; v1(68.16,83.42) 68.29,83.42 68.5,83.2 68.5,82.74 68.84,82.4 68.84,82.22 68.67,82.05 68.67,81.82 68.76,81.73 68.91,81.73 68.97,81.8 U7.B32
USB30_TX0+_C: length 1.2
  BOTTOM w0.102: C21.2 17.3,60.4 17.17,60.4 R14.2
USB30_TX0+_R: length 6.4
  BOTTOM w0.102: CN1.9 11.7,62.45 11.8,62.35 12.26,62.35 13.13,61.48 13.46,61.48 14.21,60.74 14.64,60.74 14.99,61.09 D24.1 15.59,60.65 15.79,60.65 R14.1
USB30_TX0-: length 99.2
  IN2 w0.14: v1(68.9,83.42) 68.71,83.24 68.71,82.14 68.01,81.44 68.01,79.59 67.98,79.57 67.98,77.54 65.86,75.42 62.68,75.42 61.42,76.67 59.83,76.67 58.56,77.94 56.02,77.94 54.94,79.02 54.94,81.3 53.18,83.06 53.18,86.12 49.95,89.35 49.95,89.76 49.51,90.2 37.15,90.2 36.05,89.09 28.7,89.09 27.43,87.82 25.52,87.82 24.23,86.53 24.23,80.72 23.5,79.99 22.54,79.99 21.74,79.19 21.74,76.95 25.39,73.31 25.39,63.96 21.2,59.78 19.58,59.78 v1(19.41,59.6)
  BOTTOM w0.102: v1(19.41,59.6) 19.03,59.99 18.68,59.99 C20.1 ; v1(68.9,83.42) 68.71,83.23 68.71,82.82 69.04,82.48 69.04,82.27 69.26,82.05 69.26,81.8 68.97,81.51 U7.C32
USB30_TX0-_C: length 1.3
  BOTTOM w0.102: R13.2 17.14,60.2 17.23,60.2 C20.2
USB30_TX0-_R: length 6.4
  BOTTOM w0.102: R13.1 15.97,60.07 15.6,60.44 15.18,60.44 D23.1 14.7,60.53 14.13,60.53 13.38,61.28 13.04,61.28 12.18,62.15 11.8,62.15 11.7,62.05 CN1.8
USB_1P8_PWR: length 26
  TOP w0.381: C218.1 71.13,72.73 v1(71,72.86)
  TOP w0.508: v1(91.72,76.09) 91.72,76.79 C256.1 R423.1
  IN1 w0.508: v1(91.72,76.09) 91.72,75.82 91.34,75.44 88.21,75.44 87.51,76.13 84.64,76.13 83.2,74.69 75.34,74.69 73.59,72.95 73.56,72.95 73.47,72.86 71,72.86 v1(71,72.86)
  BOTTOM w0.254: U7.AA29 70.99,72.83 70.99,72.86 v1(71,72.86)
USB_1P24_PWR: length 16.9
  TOP w0.508: R315.1 54.22,72.38 54.96,73.12 R314.1 55.59,74.51 56.67,74.51 57.35,73.83 62.06,73.83 63.26,75.03 C156.2 C149.2 66.41,75.03 67.03,74.41 v1(67.25,74.41)
  BOTTOM w0.254: U7.V35 67.61,74.05 v1(67.25,74.41) 67.27,74.43 67.5,74.66 67.61,74.77 U7.U35
USB_3P3_PWR: length 1.3
  BOTTOM w0.254: U7.B22 73.47,81.57 U7.C23
  BOTTOM w0.508: 73.83,82.57 U7.B22
USB_CAR_N: length 41.9
  IN2 w0.14: v1(24.93,32.12) 25.15,32.34 25.15,32.34 26.15,32.34 26.88,33.07 28.65,33.07 31.91,36.34 31.91,43.11 30.93,44.09 30.93,46.9 33.2,49.17 33.2,52.85 32.52,53.54 29.23,53.54 28.83,53.94 28.83,54.8 27.54,56.1 27.54,56.58 v1(27.66,56.7)
  BOTTOM w0.102: R1143.2 27.55,55.98 27.38,56.15 27.38,56.42 v1(27.66,56.7) 27.37,56.99 27.37,57.19 27.54,57.36 R1140.2 ; v1(24.93,32.12) 25.24,32.43 25.38,32.43 25.57,32.24 25.57,30.43 25.73,30.27 25.73,28.83 25.54,28.65 U23.2
USB_CAR_P: length 41.9
  IN2 w0.14: v1(24.93,32.93) 25.26,32.6 26.04,32.6 26.77,33.34 28.54,33.34 31.65,36.45 31.65,43 30.66,43.98 30.66,47.01 32.94,49.28 32.94,52.74 32.41,53.27 29.12,53.27 28.56,53.83 28.56,54.69 27.27,55.99 27.27,56.43 v1(27,56.7)
  BOTTOM w0.102: R1142.2 26.98,55.98 27.17,56.17 27.17,56.53 v1(27,56.7) 27.17,56.87 27.17,57.2 27.02,57.36 R1141.2 ; v1(24.93,32.93) 25.24,32.63 25.47,32.63 25.77,32.33 25.77,30.51 25.93,30.35 25.93,28.75 26.04,28.63 U23.3
USB_CR_N: length 6.3
  BOTTOM w0.102: R1140.1 27.33,58.14 27.26,58.21 27.26,59.05 25.98,60.33 25.98,60.72 25.1,61.6 25.1,62.14 25.25,62.29 25.34,62.29 25.53,62.09 U35.15
USB_CR_P: length 6.3
  BOTTOM w0.102: R1141.1 27.05,58.4 27.05,58.97 25.78,60.24 25.78,60.63 24.9,61.52 24.9,62.22 25.16,62.49 25.35,62.49 25.45,62.59 U35.16
USB_HSIC_RCOMP: length 1.5
  TOP w0.254: v1(65.63,76.8) 65.06,76.8 64.84,77.02 R352.2
  BOTTOM w0.254: v1(65.63,76.8) 65.67,76.8 U7.N38
USB_HUB_5V: length 4.6
  BOTTOM w0.108: TP48.1 29.85,69.56 30.1,69.31 30.1,67.15 29.58,66.63 U35.27
USB_HUB_N: length 4.8
  BOTTOM w0.102: U35.1 31.63,65.09 31.77,64.94 31.86,64.94 v1(32.46,65.55) 32.96,65.05 33.23,65.05 34.14,64.13 34.14,63.62 R1136.2
USB_HUB_P: length 4.8
  BOTTOM w0.102: R1137.2 33.8,63.35 33.94,63.48 33.94,64.05 33.14,64.84 33.01,64.84 v1(32.43,64.26) 31.95,64.74 31.79,64.74 31.64,64.59 U35.2
USB_RCOMP: length 4.7
  BOTTOM w0.203: 59.01,83.94 59.41,83.53 59.74,83.53 60.96,82.31 U7.A48
  BOTTOM w0.381: R60.2 58.78,85.6 58.78,84.16 59.01,83.94
USB_VBUSSNS: length 7.2
  BOTTOM w0.102: U7.B47 61.44,81.83 61.44,82.44 61.14,82.74 60.89,82.74 59.89,83.74 59.89,83.94
  BOTTOM w0.108: R61.1 59.29,87.21 59.16,87.08 59.16,86.21 R62.1 59.44,85.49 59.44,84.39 59.89,83.94
USBHSIC_1P24_PWR: length 15.3
  TOP w0.508: v1(64.14,77.21) 64.19,77.26 64.19,78.22 64.18,78.23 C183.2 64.18,79.7 63.45,80.43 62.97,80.43 62.11,81.3 62.08,81.3 61.49,81.88 61.06,81.88 60.22,82.72 60.22,83.3 59.87,83.66 58.04,83.66 57.53,83.15 56.39,83.15 55.25,82.01 R338.1
  BOTTOM w0.381: U7.M41 64.49,76.85 v1(64.14,77.21)
USBON#: length 304.9
  TOP w0.108: v1(138.91,75.46) 139.52,76.07 139.52,77.45 139.55,77.49 139.55,77.89 140.03,78.37 140.95,78.37 141.29,78.72 141.29,79.53 141.73,79.97 141.73,80.28 142.01,80.56 142.01,81.04 142.23,81.26 142.23,84.18 142.06,84.34 142.06,86.32 142.6,86.86 146.2,86.86 146.22,86.87 146.37,86.87 147.02,87.52 147.02,93.93 148.21,95.13 148.21,95.79 148.21,99.46 148.49,99.74 148.49,100.12 148.13,100.47 146.76,100.47 146.43,100.8 146.43,102.58 146.69,102.83 146.69,103.22 146.29,103.61 146.29,105.64 146.86,106.21 v1(147.47,106.21) ; R256.1 123.01,24.6 121.9,25.72 121.9,26.4 120.96,27.34 v1(120.96,27.52)
  IN1 w0.14: v1(18.44,54.37) 18.96,54.89 20.23,54.89 22.43,57.09 22.43,64.37 24,65.95 24,72.11 22.51,73.6 22.51,75.32 22.14,75.7 22.14,79.65 21.45,80.34 21.45,80.78 19.62,82.61 19.62,86.48 22.05,88.92 22.05,91.86 23.75,93.56 29.47,93.56 30.06,92.97 35.22,92.97 38.43,96.19 46.41,96.19 47.57,97.34 53.31,97.34 55.76,99.8 60.9,99.8 61.8,98.89 77.38,98.89 78.28,97.99 81.36,97.99 82.33,98.97 84.05,98.97 84.56,98.46 84.56,97.53 85.4,96.69 87.14,96.69 90.56,93.26 90.56,92.83 93.22,90.18 95.91,90.18 99.46,86.63 101.05,86.63 101.91,85.77 102.61,85.77 103.23,85.14 109.47,85.14 110.3,84.31 113.98,84.31 116.07,82.22 120.46,82.22 121.86,80.82 126.67,80.82 127.96,79.53 132.34,79.53 132.7,79.89 135.85,79.89 138.18,77.55 138.18,76.18 v1(138.91,75.46) 139.89,74.48 139.89,73.24 143.05,70.08 143.05,65.97 144.7,64.32 144.7,58.93 145.05,58.59 145.05,49.9 142.59,47.44 142.59,46.58 141.33,45.32 141.33,43.63 141.34,43.62 141.34,41.12 139.9,39.68 139.9,35.74 136.78,32.62 136.78,27.66 136.23,27.11 132.69,27.11 132.69,27.12 132.08,27.12 131.63,26.67 129.61,26.67 128.75,27.53 123.41,27.53 122.88,28.06 121.85,28.06 121.31,27.52 v1(120.96,27.52)
  BOTTOM w0.108: U36.4 22.41,55.76 22.02,55.37 19.38,55.37 18.44,54.42 v1(18.44,54.37) ; v1(147.47,106.21) 147.47,106.24 148.13,106.9 149.71,106.9 150.06,107.25 153.24,107.25 153.41,107.08 U1.4
USBP0+: length 109.1
  IN2 w0.14: v1(18.06,58.36) 17.77,58.66 17.77,59.41 19.27,60.91 20.89,60.91 24.6,64.62 24.6,72.9 20.54,76.97 16.67,76.97 16.13,77.51 16.13,82.11 17.3,83.28 17.3,84.7 17.17,84.83 17.17,91.96 21.48,96.27 26.28,96.27 29.46,93.09 34.99,93.09 37.21,95.32 41.83,95.32 42.81,96.29 50.24,96.29 52.23,94.3 54.99,94.3 55.77,93.53 55.77,91.49 56.88,90.38 56.88,89.31 58.45,87.75 58.45,86.43 59.22,85.66 60.09,85.66 v1(60.28,85.47)
  BOTTOM w0.102: v1(18.06,58.36) 17.76,58.06 17.76,57.67 17.15,57.06 16.79,57.06 16.67,56.95 R15.2 ; U7.C42 64.11,81.51 63.81,81.81 63.81,82.05 63.91,82.14 63.91,83.03 63.22,83.71 63.22,84.62 62.94,84.9 62.94,85.43 61.97,86.4 61.42,86.4 60.69,85.68 60.48,85.68 v1(60.28,85.47)
USBP0+_R: length 5.7
  BOTTOM w0.102: R15.1 15.49,57.06 15.36,57.06 D2.1 14.62,57.06 14.38,57.06 14.02,57.42 14.02,58.78 13.66,59.15 13.3,59.15 13.2,59.05 CN1.3
USBP0-: length 109.1
  IN2 w0.14: v1(17.21,58.36) 17.5,58.65 17.5,59.52 19.16,61.18 20.78,61.18 24.33,64.73 24.33,72.79 20.43,76.7 16.56,76.7 15.86,77.4 15.86,82.22 17.03,83.39 17.03,84.59 16.9,84.72 16.9,92.07 21.37,96.54 26.39,96.54 29.57,93.36 34.88,93.36 37.1,95.58 41.72,95.58 42.7,96.56 50.35,96.56 52.35,94.57 55.1,94.57 56.03,93.64 56.03,91.6 57.15,90.49 57.15,89.42 58.71,87.86 58.71,86.54 59.33,85.92 60.18,85.92 60.28,86.02 v1(60.28,86.23)
  BOTTOM w0.102: U7.B42 64.11,81.93 64.11,83.11 63.42,83.79 63.42,84.71 63.15,84.99 63.15,85.51 62.05,86.6 61.33,86.6 60.61,85.88 60.34,85.88 60.28,85.95 v1(60.28,86.23) ; R16.2 16.67,57.39 16.79,57.27 17.06,57.27 17.55,57.76 17.55,58.02 v1(17.21,58.36)
USBP0-_R: length 5.7
  BOTTOM w0.102: R16.1 15.49,57.27 15.41,57.27 D3.1 14.56,57.27 14.46,57.27 14.23,57.5 14.23,58.87 13.74,59.35 13.35,59.35 13.2,59.5 CN1.2
USBP1+: length 126.2
  IN2 w0.14: v1(148.5,102.92) 148.72,102.7 148.72,98.97 148.01,98.26 148.01,97.09 146.17,95.25 145.46,95.25 143.96,93.75 143.96,89.71 142.84,88.6 141.54,88.6 137.74,84.79 131.53,84.79 131.04,84.31 125.74,84.31 124.94,85.1 124.18,85.1 121.74,87.55 119.98,87.55 117.4,90.12 116.89,90.12 115.45,91.57 112.74,91.57 112.08,90.91 106.85,90.91 106.39,90.45 101.98,90.45 99.54,92.89 99.54,95.24 98.4,96.38 92.34,96.38 91.7,97.03 89.74,97.03 87.66,99.11 82.64,99.11 81.04,97.51 78.42,97.51 77.2,96.29 72.65,96.29 72.24,96.71 65.66,96.71 63.06,94.11 63.06,92.73 62.37,92.05 62.37,85.33 62.21,85.16 61.75,85.16 v1(61.6,85.32)
  BOTTOM w0.102: v1(148.5,102.92) 148.8,102.62 148.8,102.28 148.65,102.13 CN3.7 ; v1(61.6,85.32) 61.83,85.08 62.08,85.08 62.33,84.83 62.33,84.63 62.62,84.34 62.62,83.7 62.77,83.55 62.77,82.94 63.25,82.46 63.25,82.24 63.45,82.03 63.45,81.75 U7.C43
USBP1-: length 126.2
  IN2 w0.14: v1(61.6,84.56) 61.6,84.7 61.79,84.9 62.32,84.9 62.64,85.22 62.64,91.94 63.32,92.62 63.32,94 65.77,96.44 72.13,96.44 72.54,96.03 77.31,96.03 78.53,97.25 81.15,97.25 82.75,98.85 87.55,98.85 89.63,96.76 91.59,96.76 92.23,96.12 98.29,96.12 99.28,95.13 99.28,92.78 101.87,90.19 106.5,90.19 106.96,90.64 112.19,90.64 112.85,91.3 115.33,91.3 116.78,89.86 117.29,89.86 119.87,87.28 121.63,87.28 124.07,84.84 124.83,84.84 125.63,84.04 131.15,84.04 131.64,84.53 137.85,84.53 141.65,88.33 142.95,88.33 144.22,89.6 144.22,93.64 145.57,94.99 146.28,94.99 148.28,96.98 148.28,98.15 148.98,98.86 148.98,102.6 v1(149.31,102.92)
  BOTTOM w0.102: U7.B44 63.04,82.02 63.04,82.38 62.57,82.86 62.57,83.47 62.42,83.61 62.42,84.25 62.13,84.55 62.13,84.74 61.99,84.88 61.68,84.88 61.6,84.8 v1(61.6,84.56) ; v1(149.31,102.92) 149,102.62 149,102.22 149.15,102.07 CN3.6
USBP2+: length 136.9
  IN2 w0.14: v1(60.75,87.21) 60.75,87.33 60.54,87.55 59.89,87.55 57.94,89.5 57.94,90.55 56.55,91.93 56.55,94.52 54.91,96.17 51.48,96.17 50.54,97.11 42.51,97.11 41.53,96.13 36.86,96.13 34.65,93.92 29.75,93.92 26.6,97.07 20.22,97.07 16.38,93.23 16.38,84.68 15.03,83.32 15.03,82.78 15.33,82.47 15.33,77.19 16.35,76.18 19.53,76.18 23.81,71.89 23.81,64.95 20.57,61.71 18.95,61.71 15.9,58.65 15.9,54.99 16.33,54.55 17.35,54.55 18.03,55.22 20.08,55.22 26.7,61.84 31.67,61.84 32.03,61.48 32.92,61.48 33.28,61.12 33.67,61.12 33.87,61.32 33.87,61.55 33.71,61.71 v1(33.51,61.71)
  BOTTOM w0.102: v1(60.75,87.21) 60.75,87.44 60.9,87.58 61.94,87.58 63.76,85.77 63.76,85.26 64.03,84.98 64.03,83.54 64.39,83.18 64.39,82.56 64.31,82.47 64.31,82.16 64.47,82 64.47,81.86 64.36,81.75 64.36,81.64 64.43,81.57 U7.C41 ; R1137.1 33.81,62.16 33.81,62.02 v1(33.51,61.71) 33.81,61.41 33.81,61.22 R1139.1
USBP2-: length 136.9
  IN2 w0.14: v1(60.75,87.97) 60.6,87.82 60,87.82 58.21,89.61 58.21,90.66 56.82,92.04 56.82,94.63 55.02,96.43 51.59,96.43 50.65,97.37 42.4,97.37 41.42,96.4 36.75,96.4 34.54,94.19 29.86,94.19 26.71,97.34 20.11,97.34 16.12,93.34 16.12,84.79 14.76,83.43 14.76,82.67 15.06,82.36 15.06,77.08 16.24,75.91 19.42,75.91 23.54,71.78 23.54,65.06 20.46,61.98 18.84,61.98 15.63,58.76 15.63,54.88 16.22,54.28 17.46,54.28 18.14,54.96 20.19,54.96 26.81,61.57 31.56,61.57 31.92,61.22 32.81,61.22 33.17,60.85 33.78,60.85 34.14,61.21 34.14,61.54 v1(34.31,61.71)
  BOTTOM w0.102: R1136.1 34.01,62.16 34.01,62.02 v1(34.31,61.71) 34.01,61.41 34.01,61.21 R1138.1 ; U7.A41 64.6,83.26 64.24,83.62 64.24,85.06 63.96,85.34 63.96,85.85 62.02,87.78 60.94,87.78 v1(60.75,87.97)
USBP2_CAR_N: length 15.8
  IN2 w0.14: v1(34.31,59.24) 34.1,59.24 33.95,59.08 33.95,58.8 33.61,58.46 33.07,58.46 32.81,58.73 30.12,58.73 29.81,59.03 27.85,59.03 25.81,56.99 25.81,56.1 26.2,55.71 26.68,55.71 27.39,54.99 27.39,54.7 v1(27.67,54.43)
  BOTTOM w0.102: v1(27.67,54.43) 27.41,54.69 27.41,54.92 R1143.1 ; v1(34.31,59.24) 34.01,59.54 34.01,59.62 R1138.2
USBP2_CAR_P: length 15.8
  IN2 w0.14: v1(33.51,59.24) 33.68,59.06 33.68,58.91 33.49,58.73 33.18,58.73 32.92,58.99 30.23,58.99 29.92,59.3 27.74,59.3 25.54,57.1 25.54,55.99 26.09,55.44 26.57,55.44 27.13,54.88 27.13,54.69 v1(26.86,54.43)
  BOTTOM w0.102: v1(33.51,59.24) 33.81,59.54 33.81,59.62 R1139.2 ; v1(26.86,54.43) 27.21,54.77 27.21,55.01 27.02,55.2 R1142.1
USBP3+: length 30.8
  TOP w0.102: v1(73.48,99.37) 73.65,99.2 73.65,98.85 R109.2
  IN2 w0.14: v1(73.48,99.37) 73.64,99.22 73.64,98.67 73.18,98.21 65.36,98.21 61.56,94.41 61.56,87.13 60.8,86.36 60.8,85.04 60.21,84.46 60.21,83.92 60.55,83.58 60.81,83.58 v1(61.01,83.38)
  BOTTOM w0.102: v1(61.01,83.38) 61.27,83.64 61.46,83.64 62.03,83.07 62.03,82.65 62.36,82.32 62.36,82.17 62.7,81.83 U7.C45
USBP3+_R: length 3
  TOP w0.102: v1(73.51,96.89) 73.79,97.17 73.79,97.73 73.72,97.8 R109.1
  BOTTOM w0.102: v1(73.51,96.89) 73.71,96.89 74.25,96.35 CN10.27
USBP3-: length 30.8
  TOP w0.102: v1(74.25,99.37) 74.03,99.37 73.86,99.2 73.86,98.7 73.98,98.58 R106.2
  IN2 w0.14: v1(61.01,84.14) 61.01,83.93 60.92,83.84 60.66,83.84 60.48,84.03 60.48,84.35 61.06,84.93 61.06,86.25 61.82,87.01 61.82,94.3 65.47,97.95 73.29,97.95 73.91,98.56 73.91,99.18 74.1,99.37 v1(74.25,99.37)
  BOTTOM w0.102: U7.A45 62.23,82.74 62.23,83.15 61.54,83.84 61.17,83.84 61.01,84 v1(61.01,84.14)
USBP3-_R: length 3
  TOP w0.102: R106.1 74.19,97.8 73.99,97.6 73.99,97.07 74.14,96.92 v1(74.27,96.92)
  BOTTOM w0.102: CN10.28 74.75,96.44 74.61,96.58 74.31,96.58 74.19,96.7 74.19,96.84 v1(74.27,96.92)
USBP4+: length 138.5
  IN2 w0.14: v1(64.85,84.92) 64.64,84.71 64.43,84.71 63.48,85.66 63.48,91.66 64.24,92.42 64.24,93.24 66.66,95.65 71.8,95.65 72.25,95.2 77.66,95.2 78.88,96.42 83.91,96.42 84.44,96.95 85.01,96.95 85.98,95.98 91.26,95.98 91.91,95.33 91.96,95.33 91.97,95.32 97.72,95.32 98.48,94.56 98.48,92.45 101.54,89.39 107.07,89.39 107.54,89.86 113.95,89.86 114.74,89.07 116.96,89.07 119.54,86.49 121.3,86.49 124.54,83.25 128.58,83.25 129.19,82.64 130.87,82.64 131.97,83.74 138.39,83.74 142.01,87.37 143.1,87.37 145.52,89.78 145.52,92.32 145.11,92.73 145.11,93.39 145.91,94.19 146.69,94.19 149.82,97.31 149.82,100.84 154.28,105.3 154.28,108.88 153.99,109.17 153.47,109.17 153.26,109.38 v1(153.26,109.51)
  BOTTOM w0.102: U7.B40 65.23,82.07 65.23,82.45 65.94,83.16 65.94,84.32 65.63,84.62 65.15,84.62 v1(64.85,84.92) ; v1(153.26,109.51) 153.26,109.31 153.43,109.14 153.86,109.14 154.28,109.57 155.68,109.57 156.03,109.92 156.2,109.92 157.17,110.89 157.17,110.9 157.18,110.9 157.18,111.13 157.3,111.25 CN5.3
USBP4-: length 138.5
  IN2 w0.14: v1(64.85,84.16) 64.56,84.45 64.32,84.45 63.21,85.55 63.21,91.77 63.97,92.53 63.97,93.35 66.55,95.92 71.91,95.92 72.37,95.47 77.55,95.47 78.77,96.69 83.8,96.69 84.33,97.22 85.12,97.22 86.09,96.24 91.37,96.24 92.02,95.6 92.07,95.6 92.08,95.58 97.83,95.58 98.74,94.67 98.74,92.56 101.65,89.65 106.96,89.65 107.43,90.12 114.06,90.12 114.85,89.33 117.07,89.33 119.65,86.76 121.41,86.76 124.65,83.52 128.69,83.52 129.3,82.91 130.76,82.91 131.86,84.01 138.28,84.01 141.9,87.63 142.99,87.63 145.25,89.89 145.25,92.21 144.84,92.62 144.84,93.5 145.8,94.45 146.58,94.45 149.56,97.42 149.56,100.95 154.01,105.41 154.01,108.77 153.88,108.91 153.46,108.91 v1(153.26,108.7)
  BOTTOM w0.102: v1(153.26,108.7) 153.5,108.94 153.94,108.94 154.36,109.36 155.76,109.36 156.12,109.72 156.29,109.72 157.32,110.75 CN5.5 ; v1(64.85,84.16) 65.11,84.42 65.55,84.42 65.74,84.23 65.74,83.25 65.02,82.53 65.02,82.29 64.78,82.05 64.78,81.81 65.08,81.51 U7.C40
USBSSIC_1P05_PWR: length 18.7
  TOP w0.254: v1(68.07,84.62) 67.62,84.62 66.9,85.33 66.9,86.02 66.51,86.41 C158.2 66.02,86.79 66.02,87.73 R323.1 ; v1(71.02,74.42) 71.02,74.94 C166.2
  IN1 w0.254: v1(71.02,74.42) 71.02,74.62 71.76,75.35 71.76,77.74 71.1,78.4 71.1,80.51 69.7,81.91 68.81,81.91 67.57,83.15 67.57,84.12 v1(68.07,84.62)
  BOTTOM w0.254: v1(71.02,74.42) 70.64,74.04 U7.V29
USBSSIC_1P24_PWR: length 7.1
  TOP w0.508: v1(64.14,76.33) 64.14,76.12 63.68,75.66 63.01,75.66 61.86,74.5 60.51,74.5 C194.2 60.63,74.71 60.63,76.25 R347.1
  BOTTOM w0.254: v1(64.14,76.33) 64.14,76.19 U7.P41
VA1: length 13.7
  TOP w0.254: v1(21.36,86.73) 20.04,86.73 v1(18.89,87.88) PQ1.1
  TOP w0.508: PQ1.1 18.46,90.1 PR1.1 17.03,90.1 16.94,90.02 PC10.1 15.88,90.02 15.56,90.33 15.56,94.62 v1(15.75,94.81)
  BOTTOM w0.254: v1(21.36,86.73) 21.51,86.58 PD3.2
  vias: v1(6.98,99.89) v1(7.74,99.89) v1(8.48,99.9) v1(14.14,96.62) v1(14.14,95.72) v1(14.44,97.27) v1(14.92,96.31)
VA2:
  vias: v1(15.62,91.02)
VCLK_VCORE: length 2.6
  TOP w0.254: PR44.2 37.33,67.44 v1(37.52,67.62)
  BOTTOM w0.203: 37.52,67.2 37.52,67.05 38.04,66.52 PU4.15
  BOTTOM w0.254: 37.52,67.2 v1(37.52,67.62)
VCLK_VGG: length 3
  TOP w0.203: PU6.15 125.61,53.67 v1(126.19,54.24) 126.19,54.86 126.73,55.4 PR69.2
VCORE_PWRGD: length 161.7
  TOP w0.254: PR52.1 36.01,68.6 35.59,69.03 34.42,69.03 v1(33.76,69.69) ; v1(131.98,53.61) 132.21,53.61 132.43,53.39 D20.1
  IN1 w0.254: v1(34.4,56.62) 35.46,55.57 35.46,55.37 38.01,52.82 38.01,47.52 36.21,45.72 36.21,44.95 35.05,43.8 35.05,35.48 38.09,32.45 40.25,32.45 41.91,30.78 77,30.78 77.73,31.51 92.09,31.51 93.37,32.79 96.83,32.79 97.23,33.2 98.03,33.2 98.23,33 105.45,33 106.97,34.52 111.19,34.52 113.84,37.18 116.57,37.18 117.37,37.98 121,37.98 121.75,38.73 122.03,38.73 122.63,39.32 123.54,39.32 124.52,40.3 124.52,43.81 126.34,45.63 126.34,45.63 127.01,46.3 129.04,46.3 131.27,48.53 131.27,50.28 131.98,50.99 v1(131.98,53.61)
  IN2 w0.254: v1(33.76,69.69) 33.88,69.56 33.88,63.83 35.4,62.32 35.4,60.8 35.01,60.42 35.01,58.23 34.81,58.03 34.81,57.03 v1(34.4,56.62)
  BOTTOM w0.254: PR237.2 31.55,53.95 32.05,54.44 32.51,54.44 34.4,56.34 v1(34.4,56.62) ; PR38.2 35,69.54 34.85,69.69 v1(33.76,69.69)
VDIO_VCORE: length 2.2
  BOTTOM w0.203: PU4.13 38.05,65.72 37.75,66.03 v1(37.53,66.03)
  BOTTOM w0.254: PR42.1 36.81,66.17 36.96,66.03 v1(37.53,66.03)
VDIO_VGG: length 2.1
  TOP w0.203: PR76.1 126.56,53.29 v1(126.24,52.97) 126.14,52.87 PU6.13
VGG_PWRGD: length 170.7
  TOP w0.254: PR58.1 PR65.1 127.43,57.3 127.54,57.18 131.27,57.18 131.69,56.77 131.69,56.26 131.85,56.1 132.72,56.1 133.28,55.54 133.28,54.88 133.1,54.7 D21.1 132.18,54.95 v1(132.18,55.44)
  IN1 w0.254: v1(38.92,57.34) 39.01,57.26 39.01,55.46 38.88,55.32 38.01,55.32 37.77,55.08 37.77,54.69 39.08,53.38 39.08,47.08 37.28,45.27 37.28,44.51 36.2,43.44 36.2,35.84 38.53,33.51 40.69,33.51 42.35,31.85 76.55,31.85 77.77,33.07 78.04,33.07 78.46,32.65 91.67,32.65 93.52,34.5 94.89,34.5 95.96,34.5 96.16,34.31 96.2,34.26 97.6,34.26 97.82,34.48 105.26,34.48 105.69,34.91 111.02,34.91 113.68,37.57 116.4,37.57 117.21,38.37 120.84,38.37 121.59,39.12 121.87,39.12 122.47,39.72 123.38,39.72 124.12,40.46 124.12,43.97 125.95,45.79 125.95,45.79 126.85,46.69 128.88,46.69 130.87,48.69 130.87,50.45 131.59,51.16 131.59,53.27 131.46,53.39 131.46,54.41 132.18,55.13 v1(132.18,55.44)
  BOTTOM w0.254: PR234.1 44.76,66.85 45.5,66.85 45.8,67.15 46.3,67.15 47.7,65.75 47.7,65.48 49.42,63.76 49.42,59.92 46.67,57.17 39.87,57.17 39.7,57.34 v1(38.92,57.34)
VGG_SENSEN: length 25.1
  TOP w0.254: v1(109.48,63.71) 109.85,63.34 109.85,62.71 110.62,61.94 PR210.1
  BOTTOM w0.254: v1(109.48,63.71) 109.83,64.06 109.83,68.44 108.16,70.12 104.98,70.12 103.68,71.42 100.59,71.42 97.74,74.27 96.33,74.27 95.51,75.1 95.33,75.1 R188.1
